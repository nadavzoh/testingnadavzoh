* Synopsys Nettran: RHEL64 S-2021.06-SP3-2.7200131 2022/01/06
* Created:  1/18/2023   0:44
* Options: -clf /p/mpg/proc/projects/i78lncip/central_runs/lorf/samanoor/dcchunkrotd/logical_lvs/dcchunkrotd/netlists/spice/dcchunkrotd.sp.icv_nettran.clf

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: May 23 14:51:25 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mand002ab1n12x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mand002ab1n12x5
*   View name: schematic
.SUBCKT i0mand002ab1n12x5 a b o vcc vssx
*   INOUT: vcc vssx
*   INPUT: a b
*   OUTPUT: o
Mg101.qna.mn3 o n1 vssx vssx nhpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn3 n1 a g1.n1 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg1.qnb.mn3 g1.n1 b vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp3 n1 a vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg1.qpb.mp3 n1 b vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: May 23 20:07:19 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mand002ab1n09x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mand002ab1n09x5
*   View name: schematic
.SUBCKT i0mand002ab1n09x5 a b o vcc vssx
*   INOUT: vcc vssx
*   INPUT: a b
*   OUTPUT: o
Mg101.qna.mn3 o n1 vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn3 n1 a g1.n1 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qnb.mn3 g1.n1 b vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp3 n1 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpb.mp3 n1 b vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 22:22:51 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0maoi022ab1n03x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0maoi022ab1n03x5
*   View name: schematic
.SUBCKT i0maoi022ab1n03x5 a b c d o1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: a b c d
*   OUTPUT: o1
Mqnd1.mn3 n3 d vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqnb1.mn3 n2 b vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqna1.mn3 o1 a n2 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqnc1.mn3 o1 c n3 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqpa1.mp3 o1 a n1 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqpc1.mp3 n1 c vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqpd1.mp3 n1 d vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqpb1.mp3 o1 b n1 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 11:40:57 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0maoi022ab1n06x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0maoi022ab1n06x5
*   View name: schematic
.SUBCKT i0maoi022ab1n06x5 a b c d o1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: a b c d
*   OUTPUT: o1
Mqnd1.mn3 n3 d vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqnb1.mn3 n2 b vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqna1.mn3 o1 a n2 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqnc1.mn3 o1 c n3 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpa1.mp3 o1 a n1 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpc1.mp3 n1 c vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpd1.mp3 n1 d vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpb1.mp3 o1 b n1 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 12:23:53 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0maoi022ab1n09x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0maoi022ab1n09x5
*   View name: schematic
.SUBCKT i0maoi022ab1n09x5 a b c d o1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: a b c d
*   OUTPUT: o1
Mqnd1.mn3 n3 d vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqnb1.mn3 n2 b vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqna1.mn3 o1 a n2 vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqnc1.mn3 o1 c n3 vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqpa1.mp3 o1 a n1 vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqpc1.mp3 n1 c vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqpd1.mp3 n1 d vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqpb1.mp3 o1 b n1 vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 12:24:59 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mbfn000ab1n21x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mbfn000ab1n21x5
*   View name: schematic
.SUBCKT i0mbfn000ab1n21x5 a o vcc vssx
*   INOUT: vcc vssx
*   INPUT: a
*   OUTPUT: o
Mg0.qpa.mp3 n1 a vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n1 a vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpalvt W=3 L=14e-9 M=7 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpalvt W=3 L=14e-9 M=7 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 14:18:53 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mbfn000ab1n03x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mbfn000ab1n03x5
*   View name: schematic
.SUBCKT i0mbfn000ab1n03x5 a o vcc vssx
*   INOUT: vcc vssx
*   INPUT: a
*   OUTPUT: o
Mg0.qpa.mp2 n1 a vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 n1 a vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 12 00:33:36 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mbfn000ab1n18x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mbfn000ab1n18x5
*   View name: schematic
.SUBCKT i0mbfn000ab1n18x5 a o vcc vssx
*   INOUT: vcc vssx
*   INPUT: a
*   OUTPUT: o
Mg0.qpa.mp3 n1 a vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n1 a vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 17:05:19 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mbfn000ab1n09x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mbfn000ab1n09x5
*   View name: schematic
.SUBCKT i0mbfn000ab1n09x5 a o vcc vssx
*   INOUT: vcc vssx
*   INPUT: a
*   OUTPUT: o
Mg0.qpa.mp3 n1 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n1 a vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 10:01:18 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0minv000ab1n21x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0minv000ab1n21x5
*   View name: schematic
.SUBCKT i0minv000ab1n21x5 a o1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: a
*   OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=7 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=7 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 19:37:12 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0minv000ab1n06x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0minv000ab1n06x5
*   View name: schematic
.SUBCKT i0minv000ab1n06x5 a o1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: a
*   OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 02:07:17 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0minv000ab1n03x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0minv000ab1n03x5
*   View name: schematic
.SUBCKT i0minv000ab1n03x5 a o1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: a
*   OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 02:49:31 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0minv000ab1n04x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0minv000ab1n04x5
*   View name: schematic
.SUBCKT i0minv000ab1n04x5 a o1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: a
*   OUTPUT: o1
Mg101.qna.mn2 o1 a vssx vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o1 a vcc vcc phpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 21:31:10 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0minv000ab1n18x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0minv000ab1n18x5
*   View name: schematic
.SUBCKT i0minv000ab1n18x5 a o1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: a
*   OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 06:38:04 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0minv000ab1n24x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0minv000ab1n24x5
*   View name: schematic
.SUBCKT i0minv000ab1n24x5 a o1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: a
*   OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 06:38:43 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mmdn022ab1n06x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mmdn022ab1n06x5
*   View name: schematic
.SUBCKT i0mmdn022ab1n06x5 a b o1 sa vcc vssx
*   INOUT: vcc vssx
*   INPUT: a b sa
*   OUTPUT: o1
Mg5.qpsb.mp3 o1 sa n1 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg5.qns.mn3 o1 n2 n1 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg2.qpsb.mp3 o1 n2 n0 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg2.qns.mn3 o1 sa n0 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg3.qpa.mp3 n2 sa vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3.qna.mn3 n2 sa vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp3 n0 a vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn3 n0 a vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg4.qpa.mp3 n1 b vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg4.qna.mn3 n1 b vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 06:34:29 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mnand02ab1n12x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mnand02ab1n12x5
*   View name: schematic
.SUBCKT i0mnand02ab1n12x5 a b o1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: a b
*   OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b vssx vssx nhpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpalvt W=2 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpalvt W=2 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 22:43:30 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mnand02ac1n03x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mnand02ac1n03x5
*   View name: schematic
.SUBCKT i0mnand02ac1n03x5 a b o1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: a b
*   OUTPUT: o1
Mg0.qna.mn2 o1 a g0.n1 vssx nhpasvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 g0.n1 b vssx vssx nhpasvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp3 o1 b vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Sep  1 23:26:06 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mcilb81ab1n18x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mcilb81ab1n18x5
*   View name: schematic
.SUBCKT i0mcilb81ab1n18x5 clk clkout en te vcc vssx
*   INOUT: vcc vssx
*   INPUT: clk en te
*   OUTPUT: clkout
Mg3.qnck.mn2 nk1 nc3 g3.n2 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3.qnd.mn2 g3.n2 nk2 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3.qpckb.mp2 nk1 nc2 g3.n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3.qpd.mp2 g3.n1 nk2 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qp0.mp3 clkout nc9 vcc vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg101.qn0.mn3 clkout nc9 vssx vssx nhpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg42.qpb.mp2 g42.n1 te vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg42.qpa.mp2 n8 en g42.n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg42.qnb.mn2 n8 te vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg42.qna.mn2 n8 en vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg43.qpb.mp3 g43.n1 n7 vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg43.qpa.mp3 nc9 clk g43.n1 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg43.qnb.mn2 nc9 n7 vssx vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg43.qna.mn2 nc9 clk vssx vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp2 nc2 nc3 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 nc2 nc3 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 nc3 clk vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 nc3 clk vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg5.qpa.mp2 n7 nk2 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg5.qna.mn2 n7 nk2 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg4.qpa.mp2 nk2 nk1 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg4.qna.mn2 nk2 nk1 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qpsb.mp2 nk1 nc3 n8 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qns.mn2 nk1 nc2 n8 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 12 01:33:25 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mlsn280ab1d09x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mlsn280ab1d09x5
*   View name: schematic
.SUBCKT i0mlsn280ab1d09x5 clkb d1 d2 o1 o2 vcc vssx
*   INOUT: vcc vssx
*   INPUT: clkb d1 d2
*   OUTPUT: o1 o2
Mg2lp1.qpa.mp2 nk12 nk11 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qna.mn2 nk12 nk11 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg21.qpa.mp3 n13 d1 vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg21.qna.mn3 n13 d1 vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg22.qpa.mp3 n23 d2 vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg22.qna.mn3 n23 d2 vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg2lp2.qpa.mp2 nk22 nk21 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp2.qna.mn2 nk22 nk21 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp2 nc1 clkb vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 nc1 clkb vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qpsb.mp3 nk11 clkb n13 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qns.mn3 nk11 nc1 n13 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp2.qpsb.mp3 nk21 clkb n23 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp2.qns.mn3 nk21 nc1 n23 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg102.qna.mn3 o2 nk21 vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg102.qpa.mp3 o2 nk21 vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o1 nk11 vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 nk11 vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnck.mn2 nk11 clkb g3lp1.n2 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnd.mn2 g3lp1.n2 nk12 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpckb.mp2 nk11 nc1 g3lp1.n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpd.mp2 g3lp1.n1 nk12 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp2.qnck.mn2 nk21 clkb g3lp2.n2 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp2.qnd.mn2 g3lp2.n2 nk22 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp2.qpckb.mp2 nk21 nc1 g3lp2.n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp2.qpd.mp2 g3lp2.n1 nk22 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 02:08:07 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqsnbf1ab1n12x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqsnbf1ab1n12x5
*   View name: schematic
.SUBCKT i0mqsnbf1ab1n12x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqp0.mp3 n0p vssx vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 nop vssx vcc vcc phpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mqn0.mn3 n0n vssx vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn3 non vssx vssx vssx nhpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 04:29:02 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqsnna3ab1n06x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqsnna3ab1n06x5
*   View name: schematic
.SUBCKT i0mqsnna3ab1n06x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqnb1.mn3 n1 vssx n2 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqna1.mn3 no1n vssx n1 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqnc1.mn3 n2 vssx vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpb1.mp3 no1p vssx vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpc1.mp3 no1p vssx vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpa1.mp3 no1p vssx vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 12 04:00:08 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mzdcf33ub1n32x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mzdcf33ub1n32x5
*   View name: schematic
.SUBCKT i0mzdcf33ub1n32x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqpdecap1.mp3 vcc vssx vcc vcc phpalvt W=3 L=14e-9 M=24 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 14:46:05 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mzdcf33ub1n04x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mzdcf33ub1n04x5
*   View name: schematic
.SUBCKT i0mzdcf33ub1n04x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqpdecap1.mp3 vcc vssx vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 14:25:41 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqsnbf1ab1n18x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqsnbf1ab1n18x5
*   View name: schematic
.SUBCKT i0mqsnbf1ab1n18x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqp0.mp3 n0p vssx vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 nop vssx vcc vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mqn0.mn3 n0n vssx vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqn1.mn3 non vssx vssx vssx nhpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 06:24:23 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqsnin1ab1n12x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqsnin1ab1n12x5
*   View name: schematic
.SUBCKT i0mqsnin1ab1n12x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqn1.mn3 no1n vssx vssx vssx nhpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 no1p vssx vcc vcc phpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 14:43:53 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqsnca4ab1n06x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqsnca4ab1n06x5
*   View name: schematic
.SUBCKT i0mqsnca4ab1n06x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqnd1.mn3 n3 vssx vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqnb1.mn3 n2 vssx vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqna1.mn3 no1n vssx n2 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqnc1.mn3 no1n vssx n3 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpa1.mp3 no1p vssx n1 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpc1.mp3 n1 vssx vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpd1.mp3 n1 vssx vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpb1.mp3 no1p vssx n1 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 04:31:14 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqsnno3ab1n06x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqsnno3ab1n06x5
*   View name: schematic
.SUBCKT i0mqsnno3ab1n06x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqnc1.mn3 no1n vssx vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqnb1.mn3 no1n vssx vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqna1.mn3 no1n vssx vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpb1.mp3 n1 vssx n2 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpc1.mp3 n2 vssx vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpa1.mp3 no1p vssx n1 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 11:31:46 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqsnin1ab1n18x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqsnin1ab1n18x5
*   View name: schematic
.SUBCKT i0mqsnin1ab1n18x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqn1.mn3 no1n vssx vssx vssx nhpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 no1p vssx vcc vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 02:46:44 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqsnfs4ab1d06x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqsnfs4ab1d06x5
*   View name: schematic
.SUBCKT i0mqsnfs4ab1d06x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqn1.mn3 no1n nk5 vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mgfb2.qpa.mp2 n4 n3 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgfb2.qna.mn2 n4 n3 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgsel2.qpa.mp2 n6 n5 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgsel2.qna.mn2 n6 n5 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgclkn.qpa.mp2 nc1 vssx vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgclkn.qna.mn2 nc1 vssx vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd1n.qpa.mp2 nk4 nk3 vcc vcc phpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mgd1n.qna.mn2 nk4 nk3 vssx vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mgd2n.qpa.mp2 nk6 nk5 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd2n.qna.mn2 nk6 nk5 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgclkdd.qpa.mp2 nc2 nc1 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgclkdd.qna.mn2 nc2 nc1 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 no1p nk5 vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mgtd2.qpsb.mp2 nk5 nc1 nk4 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgtd2.qns.mn2 nk5 nc2 nk4 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgtd1.qnck.mn2 nk3 nc1 gtd1.n2 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgtd1.qnd.mn2 gtd1.n2 n1 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgtd1.qpckb.mp2 nk3 nc2 gtd1.n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgtd1.qpd.mp2 gtd1.n1 n1 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgin1.qnck.mn2 n1 n6 gin1.n2 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgin1.qnd.mn2 gin1.n2 vssx vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgin1.qpckb.mp2 n1 n5 gin1.n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgin1.qpd.mp2 gin1.n1 vssx vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgfb3.qnck.mn2 n1 n5 gfb3.n2 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgfb3.qnd.mn2 gfb3.n2 n4 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgfb3.qpckb.mp2 n1 n6 gfb3.n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgfb3.qpd.mp2 gfb3.n1 n4 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd1.qnck.mn2 nk3 nc2 gd1.n2 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd1.qnd.mn2 gd1.n2 nk4 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd1.qpckb.mp2 nk3 nc1 gd1.n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd1.qpd.mp2 gd1.n1 nk4 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd2.qnck.mn2 nk5 nc1 gd2.n2 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd2.qnd.mn2 gd2.n2 nk6 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd2.qpckb.mp2 nk5 nc2 gd2.n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd2.qpd.mp2 gd2.n1 nk6 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgfb1.qna.mn2 n3 vssx gfb1.n1 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgfb1.qnb.mn2 gfb1.n1 nk6 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgfb1.qpa.mp2 n3 vssx vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgfb1.qpb.mp2 n3 nk6 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgsel1.qna.mn2 n5 vssx gsel1.n1 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgsel1.qnb.mn2 gsel1.n1 vssx vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgsel1.qpa.mp2 n5 vssx vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgsel1.qpb.mp2 n5 vssx vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 20:52:14 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mydp122ub1n00x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mydp122ub1n00x5
*   View name: schematic
.SUBCKT i0mydp122ub1n00x5 dpd1 vcc vssx
*   INOUT: vcc vssx
*   INPUT: dpd1
*   OUTPUT:
Mqngnac1.mn2 dpd1 vssx vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 06:31:00 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqsnls3ab1d06x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqsnls3ab1d06x5
*   View name: schematic
.SUBCKT i0mqsnls3ab1d06x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mg1lp1.qpsb.mp2 nk1 vssx n3 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qns.mn2 nk1 nc1 n3 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qna.mn3 n3 vssx g2.n1 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qnb.mn3 g2.n1 vssx vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qpa.mp3 n3 vssx vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qpb.mp3 n3 vssx vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn3 no1n nk1 vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg2lp1.qpa.mp2 nk2 nk1 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qna.mn2 nk2 nk1 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp2 nc1 vssx vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 nc1 vssx vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnck.mn2 nk1 vssx g3lp1.n2 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnd.mn2 g3lp1.n2 nk2 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpckb.mp2 nk1 nc1 g3lp1.n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpd.mp2 g3lp1.n1 nk2 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 no1p nk1 vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 04:30:06 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mzdcf33ub1n08x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mzdcf33ub1n08x5
*   View name: schematic
.SUBCKT i0mzdcf33ub1n08x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqpdecap1.mp3 vcc vssx vcc vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 11 17:11:16 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mzdcf33ub1n16x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mzdcf33ub1n16x5
*   View name: schematic
.SUBCKT i0mzdcf33ub1n16x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqpdecap1.mp3 vcc vssx vcc vcc phpalvt W=3 L=14e-9 M=12 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Nov  3 10:17:31 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqbnna2bc1d20x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqbnna2bc1d20x5
*   View name: schematic
.SUBCKT i0mqbnna2bc1d20x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqnb.mn3 n1 nb vssx vssx nhpasvt W=3 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Mqna.mn3 no na n1 vssx nhpasvt W=3 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Rg1 n101 vssx rtcnfm1 W=16e-9 L=9e-9 M=1
Rra na n101 rbm0fbm1 W=80e-9 L=40e-9 M=1
Rrb nb n101 rbm0fbm1 W=80e-9 L=40e-9 M=1
Mqpb.mp2 no nb vcc vcc phpasvt W=2 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Mqpa.mp2 no na vcc vcc phpasvt W=2 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Nov  3 10:15:38 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqbnno2bc1d20x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqbnno2bc1d20x5
*   View name: schematic
.SUBCKT i0mqbnno2bc1d20x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqna.mn2 no na vssx vssx nhpasvt W=2 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Mqnb.mn2 no nb vssx vssx nhpasvt W=2 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Mqpa.mp3 no na n1 vcc phpasvt W=3 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Mqpb.mp3 n1 nb vcc vcc phpasvt W=3 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Rrb nb n101 rbm0fbm1 W=80e-9 L=40e-9 M=1
Rg1 n101 vssx rtcnfm1 W=16e-9 L=9e-9 M=1
Rra na n101 rbm0fbm1 W=80e-9 L=40e-9 M=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Nov  3 10:16:13 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqbnbf2bc1d30x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqbnbf2bc1d30x5
*   View name: schematic
.SUBCKT i0mqbnbf2bc1d30x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Rra na n101 rbm0fbm1 W=80e-9 L=40e-9 M=1
Rg1 n101 vssx rtcnfm1 W=16e-9 L=9e-9 M=1
Rrb nb na rbm0fbm1 W=80e-9 L=40e-9 M=1
Mqnb.mn3 no2 nb vssx vssx nhpasvt W=3 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Mqna.mn3 no1 na vssx vssx nhpasvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mqpb.mp3 no2 nb vcc vcc phpasvt W=3 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Mqpa.mp3 no1 na vcc vcc phpasvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun 12 02:03:28 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mqsnco4ab1n06x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mqsnco4ab1n06x5
*   View name: schematic
.SUBCKT i0mqsnco4ab1n06x5 vcc vssx
*   INOUT: vcc vssx
*   INPUT:
*   OUTPUT:
Mqpc1.mp3 no1p vssx n3 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpa1.mp3 no1p vssx n2 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpb1.mp3 n2 vssx vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpd1.mp3 n3 vssx vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqnb1.mn3 no1n vssx n1 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqnd1.mn3 n1 vssx vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqnc1.mn3 n1 vssx vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqna1.mn3 no1n vssx n1 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*   Netlist Is Generated By VMAC Netlister
*   VMAC version : 20.06.26_rc
*   Generated for: hspiceD
*   Generated on: Jun  6 16:09:30 2022
*   Design library name: flat_schematic_lib
*   Design cell name: i0mcrb0bfab1n18x5
*   Design view name: schematic
*   Library name: flat_schematic_lib
*   Cell name: i0mcrb0bfab1n18x5
*   View name: schematic
.SUBCKT i0mcrb0bfab1n18x5 clk clkout fd rd vcc vssx
*   INOUT: vcc vssx
*   INPUT: clk fd rd
*   OUTPUT: clkout
Mg101.qp0.mp3 clkout n0 vcc vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg101.qn0.mn3 clkout n0 vssx vssx nhpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mqp11.mp3 n1 fd vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqp0.mp3 n0 clk n1 vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqp100.mp2 n1 vssx vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn11.mn3 n2 rd vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqn101.mn3 nvss0 n1 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn100.mn2 n2 n1 nvss0 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn0.mn3 n0 clk n2 vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

.SUBCKT dcrotlddec2to4 chunkrotctrlm403l[1] chunkrotctrlm403l[0] chunkrotctrlm403l_sel[3]
+ chunkrotctrlm403l_sel[2] chunkrotctrlm403l_sel[1] chunkrotctrlm403l_sel[0] vcc
+ vss
Xi2[0] chunkrotctrlm403l[0] chunkrotctrlm403l#[0] vcc vss i0minv000ab1n06x5
Xi4[3] chunkrotctrlm403l[0] chunkrotctrlm403l[1] chunkrotctrlm403l_sel[3] vcc vss i0mand002ab1n12x5
Xi4[2] chunkrotctrlm403l#[0] chunkrotctrlm403l[1] chunkrotctrlm403l_sel[2] vcc vss i0mand002ab1n12x5
Xi4[1] chunkrotctrlm403l[0] chunkrotctrlm403l#[1] chunkrotctrlm403l_sel[1] vcc vss i0mand002ab1n12x5
Xi4[0] chunkrotctrlm403l#[0] chunkrotctrlm403l#[1] chunkrotctrlm403l_sel[0] vcc
+ vss i0mand002ab1n12x5
Xi2[1] chunkrotctrlm403l[1] chunkrotctrlm403l#[1] vcc vss i0minv000ab1n06x5
Xgnac0 chunkrotctrlm403l[0] vcc vss i0mydp122ub1n00x5
Xgnac1 chunkrotctrlm403l[1] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcrotdec2to4_l stchunkrotctrlm403h[1] stchunkrotctrlm403h[0] stchunkrotctrlm403h_sel[3]
+ stchunkrotctrlm403h_sel[2] stchunkrotctrlm403h_sel[1] stchunkrotctrlm403h_sel[0]
+ vcc vss
Xi2[1] stchunkrotctrlm403h[1] stchunkrotctrlm403h#[1] vcc vss i0minv000ab1n03x5
Xi4[0] stchunkrotctrlm403h#[0] stchunkrotctrlm403h#[1] stchunkrotctrlm403h_sel[0]
+ vcc vss i0mand002ab1n09x5
Xi4[1] stchunkrotctrlm403h[0] stchunkrotctrlm403h#[1] stchunkrotctrlm403h_sel[1]
+ vcc vss i0mand002ab1n09x5
Xi4[2] stchunkrotctrlm403h#[0] stchunkrotctrlm403h[1] stchunkrotctrlm403h_sel[2]
+ vcc vss i0mand002ab1n09x5
Xi4[3] stchunkrotctrlm403h[0] stchunkrotctrlm403h[1] stchunkrotctrlm403h_sel[3]
+ vcc vss i0mand002ab1n09x5
Xi2[0] stchunkrotctrlm403h[0] stchunkrotctrlm403h#[0] vcc vss i0minv000ab1n03x5
Xgnac0 stchunkrotctrlm403h[0] vcc vss i0mydp122ub1n00x5
Xgnac1 stchunkrotctrlm403h[1] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcrotdec2to4_r stchunkrotctrlm403h[1] stchunkrotctrlm403h[0] stchunkrotctrlm403h_sel[3]
+ stchunkrotctrlm403h_sel[2] stchunkrotctrlm403h_sel[1] stchunkrotctrlm403h_sel[0]
+ vcc vss
Xi2[1] stchunkrotctrlm403h[1] stchunkrotctrlm403h#[1] vcc vss i0minv000ab1n04x5
Xi4[0] stchunkrotctrlm403h#[0] stchunkrotctrlm403h#[1] stchunkrotctrlm403h_sel[0]
+ vcc vss i0mand002ab1n09x5
Xi4[1] stchunkrotctrlm403h[0] stchunkrotctrlm403h#[1] stchunkrotctrlm403h_sel[1]
+ vcc vss i0mand002ab1n09x5
Xi4[2] stchunkrotctrlm403h#[0] stchunkrotctrlm403h[1] stchunkrotctrlm403h_sel[2]
+ vcc vss i0mand002ab1n09x5
Xi4[3] stchunkrotctrlm403h[0] stchunkrotctrlm403h[1] stchunkrotctrlm403h_sel[3]
+ vcc vss i0mand002ab1n09x5
Xi2[0] stchunkrotctrlm403h[0] stchunkrotctrlm403h#[0] vcc vss i0minv000ab1n04x5
Xgnac0 stchunkrotctrlm403h[0] vcc vss i0mydp122ub1n00x5
Xgnac1 stchunkrotctrlm403h[1] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcrotdec2to4_r2 stchunkrotctrlm403h[1] stchunkrotctrlm403h[0] stchunkrotctrlm403h_sel[3]
+ stchunkrotctrlm403h_sel[2] stchunkrotctrlm403h_sel[1] stchunkrotctrlm403h_sel[0]
+ vcc vss
Xi2[0] stchunkrotctrlm403h[0] stchunkrotctrlm403h#[0] vcc vss i0minv000ab1n03x5
Xi4[3] stchunkrotctrlm403h[0] stchunkrotctrlm403h[1] stchunkrotctrlm403h_sel[3]
+ vcc vss i0mand002ab1n09x5
Xi4[2] stchunkrotctrlm403h#[0] stchunkrotctrlm403h[1] stchunkrotctrlm403h_sel[2]
+ vcc vss i0mand002ab1n09x5
Xi4[1] stchunkrotctrlm403h[0] stchunkrotctrlm403h#[1] stchunkrotctrlm403h_sel[1]
+ vcc vss i0mand002ab1n09x5
Xi4[0] stchunkrotctrlm403h#[0] stchunkrotctrlm403h#[1] stchunkrotctrlm403h_sel[0]
+ vcc vss i0mand002ab1n09x5
Xi2[1] stchunkrotctrlm403h[1] stchunkrotctrlm403h#[1] vcc vss i0minv000ab1n03x5
Xgnac0 stchunkrotctrlm403h[1] vcc vss i0mydp122ub1n00x5
Xgnac1 stchunkrotctrlm403h[0] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcrotdec2to4_l2 stchunkrotctrlm403h[1] stchunkrotctrlm403h[0] stchunkrotctrlm403h_sel[3]
+ stchunkrotctrlm403h_sel[2] stchunkrotctrlm403h_sel[1] stchunkrotctrlm403h_sel[0]
+ vcc vss
Xirep[0] stchunkrotctrlm403h[0] stchunkrotctrlm403h_rep[0] vcc vss i0mbfn000ab1n03x5
Xirep[1] stchunkrotctrlm403h[1] stchunkrotctrlm403h_rep[1] vcc vss i0mbfn000ab1n03x5
Xi2[0] stchunkrotctrlm403h[0] stchunkrotctrlm403h#[0] vcc vss i0minv000ab1n03x5
Xi4[3] stchunkrotctrlm403h_rep[0] stchunkrotctrlm403h_rep[1] stchunkrotctrlm403h_sel[3]
+ vcc vss i0mand002ab1n09x5
Xi4[2] stchunkrotctrlm403h#[0] stchunkrotctrlm403h_rep[1] stchunkrotctrlm403h_sel[2]
+ vcc vss i0mand002ab1n09x5
Xi4[1] stchunkrotctrlm403h_rep[0] stchunkrotctrlm403h#[1] stchunkrotctrlm403h_sel[1]
+ vcc vss i0mand002ab1n09x5
Xi4[0] stchunkrotctrlm403h#[0] stchunkrotctrlm403h#[1] stchunkrotctrlm403h_sel[0]
+ vcc vss i0mand002ab1n09x5
Xi2[1] stchunkrotctrlm403h[1] stchunkrotctrlm403h#[1] vcc vss i0minv000ab1n03x5
Xgnac0 stchunkrotctrlm403h[1] vcc vss i0mydp122ub1n00x5
Xgnac1 stchunkrotctrlm403h[0] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcu_store_rot_4bit sellch0[3] sellch0[2] sellch0[1] sellch0[0] sellch1[3]
+ sellch1[2] sellch1[1] sellch1[0] sellch2[3] sellch2[2] sellch2[1] sellch2[0] sellch3[3]
+ sellch3[2] sellch3[1] sellch3[0] stclk403l[3] stclk403l[2] stclk403l[1] stclk403l[0]
+ stdatam403l_rep_0_[1] stdatam403l_rep_0_[0] stdatam403l_rep_1_[1] stdatam403l_rep_1_[0]
+ stdatam403l_rep_2_[1] stdatam403l_rep_2_[0] stdatam403l_rep_3_[1] stdatam403l_rep_3_[0]
+ strotalgnbdatchunkm403h[0][1] strotalgnbdatchunkm403h[0][0] strotalgnbdatchunkm403h[1][1]
+ strotalgnbdatchunkm403h[1][0] strotalgnbdatchunkm403h[2][1] strotalgnbdatchunkm403h[2][0]
+ strotalgnbdatchunkm403h[3][1] strotalgnbdatchunkm403h[3][0] vcc vss
Xi7 stclk403l[2] stdatamx2403h[4] stdatamx2403h[5] stdatam403l[4] stdatam403l[5]
+ vcc vss i0mlsn280ab1d09x5
Xi1 stclk403l[0] stdatamx2403h[0] stdatamx2403h[1] stdatam403l[0] stdatam403l[1]
+ vcc vss i0mlsn280ab1d09x5
Xi4 stclk403l[3] stdatamx2403h[6] stdatamx2403h[7] stdatam403l[6] stdatam403l[7]
+ vcc vss i0mlsn280ab1d09x5
Xi6[0] stdatam403l[4] stdatam403l_rep_2_[0] vcc vss i0mbfn000ab1n21x5
Xi6[1] stdatam403l[5] stdatam403l_rep_2_[1] vcc vss i0mbfn000ab1n21x5
Xi6[2] stdatam403l[6] stdatam403l_rep_3_[0] vcc vss i0mbfn000ab1n21x5
Xi6[3] stdatam403l[7] stdatam403l_rep_3_[1] vcc vss i0mbfn000ab1n21x5
Xi3[2] stdatam403l[2] stdatam403l_rep_1_[0] vcc vss i0mbfn000ab1n21x5
Xi3[1] stdatam403l[1] stdatam403l_rep_0_[1] vcc vss i0mbfn000ab1n21x5
Xi3[0] stdatam403l[0] stdatam403l_rep_0_[0] vcc vss i0mbfn000ab1n21x5
Xi3[3] stdatam403l[3] stdatam403l_rep_1_[1] vcc vss i0mbfn000ab1n21x5
Xi2[2] stclk403l[1] stdatamx2403h[2] stdatamx2403h[3] stdatam403l[2] stdatam403l[3]
+ vcc vss i0mlsn280ab1d09x5
Xi8_mux2 sellch0[0] strotalgnbdatchunkm403h[0][1] sellch0[3] strotalgnbdatchunkm403h[1][1]
+ zn_1 vcc vss i0maoi022ab1n03x5
Xi8_mux3 sellch3[3] strotalgnbdatchunkm403h[0][0] sellch3[2] strotalgnbdatchunkm403h[1][0]
+ zn_11 vcc vss i0maoi022ab1n03x5
Xi8_mux4 sellch0[2] strotalgnbdatchunkm403h[2][0] sellch0[1] strotalgnbdatchunkm403h[3][0]
+ zn_0 vcc vss i0maoi022ab1n03x5
Xi8_mux5 sellch0[2] strotalgnbdatchunkm403h[2][1] sellch0[1] strotalgnbdatchunkm403h[3][1]
+ zn_2 vcc vss i0maoi022ab1n03x5
Xi8_mux6 sellch3[1] strotalgnbdatchunkm403h[2][0] sellch3[0] strotalgnbdatchunkm403h[3][0]
+ zn_12 vcc vss i0maoi022ab1n03x5
Xi8_mux7 sellch1[1] strotalgnbdatchunkm403h[0][1] sellch1[0] strotalgnbdatchunkm403h[1][1]
+ zn_5 vcc vss i0maoi022ab1n03x5
Xi8_mux8 sellch0[0] strotalgnbdatchunkm403h[0][0] sellch0[3] strotalgnbdatchunkm403h[1][0]
+ zn vcc vss i0maoi022ab1n03x5
Xi8_mux9 sellch2[0] strotalgnbdatchunkm403h[2][0] sellch2[3] strotalgnbdatchunkm403h[3][0]
+ zn_8 vcc vss i0maoi022ab1n03x5
Xi8_mux10 sellch3[3] strotalgnbdatchunkm403h[0][1] sellch3[2] strotalgnbdatchunkm403h[1][1]
+ zn_13 vcc vss i0maoi022ab1n03x5
Xi8_mux11 sellch1[3] strotalgnbdatchunkm403h[2][1] sellch1[2] strotalgnbdatchunkm403h[3][1]
+ zn_6 vcc vss i0maoi022ab1n03x5
Xi8_mux12 sellch1[1] strotalgnbdatchunkm403h[0][0] sellch1[0] strotalgnbdatchunkm403h[1][0]
+ zn_3 vcc vss i0maoi022ab1n03x5
Xi8_mux13 sellch2[2] strotalgnbdatchunkm403h[0][1] sellch2[1] strotalgnbdatchunkm403h[1][1]
+ zn_9 vcc vss i0maoi022ab1n03x5
Xi8_mux14 sellch3[1] strotalgnbdatchunkm403h[2][1] sellch3[0] strotalgnbdatchunkm403h[3][1]
+ zn_14 vcc vss i0maoi022ab1n03x5
Xi8_mux15 sellch2[2] strotalgnbdatchunkm403h[0][0] sellch2[1] strotalgnbdatchunkm403h[1][0]
+ zn_7 vcc vss i0maoi022ab1n03x5
Xi8_mux16 sellch1[3] strotalgnbdatchunkm403h[2][0] sellch1[2] strotalgnbdatchunkm403h[3][0]
+ zn_4 vcc vss i0maoi022ab1n03x5
Xi8_mux17 sellch2[0] strotalgnbdatchunkm403h[2][1] sellch2[3] strotalgnbdatchunkm403h[3][1]
+ zn_10 vcc vss i0maoi022ab1n03x5
Xi14 zn_7 zn_8 stdatamx2403h[4] vcc vss i0mnand02ac1n03x5
Xi15 zn_13 zn_14 stdatamx2403h[7] vcc vss i0mnand02ac1n03x5
Xi16 zn_1 zn_2 stdatamx2403h[1] vcc vss i0mnand02ac1n03x5
Xi17 zn_3 zn_4 stdatamx2403h[2] vcc vss i0mnand02ac1n03x5
Xi18 zn_9 zn_10 stdatamx2403h[5] vcc vss i0mnand02ac1n03x5
Xi19 zn_11 zn_12 stdatamx2403h[6] vcc vss i0mnand02ac1n03x5
Xi110 zn zn_0 stdatamx2403h[0] vcc vss i0mnand02ac1n03x5
Xi111 zn_5 zn_6 stdatamx2403h[3] vcc vss i0mnand02ac1n03x5
Xgnac0 strotalgnbdatchunkm403h[2][1] vcc vss i0mydp122ub1n00x5
Xgnac1 strotalgnbdatchunkm403h[0][1] vcc vss i0mydp122ub1n00x5
Xgnac2 strotalgnbdatchunkm403h[3][0] vcc vss i0mydp122ub1n00x5
Xgnac3 strotalgnbdatchunkm403h[1][0] vcc vss i0mydp122ub1n00x5
Xgnac4 strotalgnbdatchunkm403h[2][0] vcc vss i0mydp122ub1n00x5
Xgnac5 strotalgnbdatchunkm403h[1][1] vcc vss i0mydp122ub1n00x5
Xgnac6 strotalgnbdatchunkm403h[3][1] vcc vss i0mydp122ub1n00x5
Xgnac7 strotalgnbdatchunkm403h[0][0] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcu_rotc_2bit chunk0sel_not[1] chunk0sel_not[0] chunk1sel_not[1] chunk1sel_not[0]
+ chunkrotoutintnobcstm403l_0_rep[1] chunkrotoutintnobcstm403l_0_rep[0] chunkrotoutintnobcstm403l_1_rep[1]
+ chunkrotoutintnobcstm403l_1_rep[0] chunkrotoutvecnobcstm403l_0_rep[1] chunkrotoutvecnobcstm403l_0_rep[0]
+ chunkrotoutvecnobcstm403l_1_rep[1] chunkrotoutvecnobcstm403l_1_rep[0] unaligndatl1am403l[0][1]
+ unaligndatl1am403l[0][0] unaligndatl1am403l[1][1] unaligndatl1am403l[1][0] unaligndatl1am403l[2][1]
+ unaligndatl1am403l[2][0] unaligndatl1am403l[3][1] unaligndatl1am403l[3][0] vcc
+ vss
Xmu[1] unaligndatl1am403l[0][1] chunk0sel_not[1] unaligndatl1am403l[2][1] sel0_[1]
+ zn[1] vcc vss i0maoi022ab1n03x5
Xmu[0] unaligndatl1am403l[0][0] chunk0sel_not[1] unaligndatl1am403l[2][0] sel0_[1]
+ zn[0] vcc vss i0maoi022ab1n03x5
Xmu4[1] unaligndatl1am403l[2][1] chunk1sel_not[1] unaligndatl1am403l[0][1] sel1_[1]
+ zn_2[1] vcc vss i0maoi022ab1n03x5
Xmu4[0] unaligndatl1am403l[2][0] chunk1sel_not[1] unaligndatl1am403l[0][0] sel1_[1]
+ zn_2[0] vcc vss i0maoi022ab1n03x5
Xmu3[1] zn_1[1] chunk1sel_not[0] zn_2[1] sel1_[0] chunkrotoutnobcstm403l_1_[3] vcc
+ vss i0maoi022ab1n09x5
Xmu3[0] zn_1[0] chunk1sel_not[0] zn_2[0] sel1_[0] chunkrotoutnobcstm403l_1_[2] vcc
+ vss i0maoi022ab1n09x5
Xmu2[1] unaligndatl1am403l[1][1] chunk1sel_not[1] unaligndatl1am403l[3][1] sel1_[1]
+ zn_1[1] vcc vss i0maoi022ab1n03x5
Xmu2[0] unaligndatl1am403l[1][0] chunk1sel_not[1] unaligndatl1am403l[3][0] sel1_[1]
+ zn_1[0] vcc vss i0maoi022ab1n03x5
Xmu1[1] unaligndatl1am403l[1][1] chunk0sel_not[1] unaligndatl1am403l[3][1] sel0_[1]
+ zn_0[1] vcc vss i0maoi022ab1n03x5
Xmu1[0] unaligndatl1am403l[1][0] chunk0sel_not[1] unaligndatl1am403l[3][0] sel0_[1]
+ zn_0[0] vcc vss i0maoi022ab1n03x5
Xmu0[1] zn[1] chunk0sel_not[0] zn_0[1] sel0_[0] chunkrotoutnobcstm403l_0_[1] vcc
+ vss i0maoi022ab1n09x5
Xmu0[0] zn[0] chunk0sel_not[0] zn_0[0] sel0_[0] chunkrotoutnobcstm403l_0_[0] vcc
+ vss i0maoi022ab1n09x5
Xchunk1[1] chunk1sel_not[1] sel1_[1] vcc vss i0minv000ab1n06x5
Xchunk1[0] chunk1sel_not[0] sel1_[0] vcc vss i0minv000ab1n06x5
Xchunk0[1] chunk0sel_not[1] sel0_[1] vcc vss i0minv000ab1n06x5
Xchunk0[0] chunk0sel_not[0] sel0_[0] vcc vss i0minv000ab1n06x5
Xbuffer_vec1[1] chunkrotoutnobcstm403l_1_[3] chunkrotoutvecnobcstm403l_1_rep[1]
+ vcc vss i0mbfn000ab1n21x5
Xbuffer_vec0[0] chunkrotoutnobcstm403l_0_[0] chunkrotoutvecnobcstm403l_0_rep[0]
+ vcc vss i0mbfn000ab1n21x5
Xbuffer_vec1[0] chunkrotoutnobcstm403l_1_[2] chunkrotoutvecnobcstm403l_1_rep[0]
+ vcc vss i0mbfn000ab1n21x5
Xbuffer_vec0[1] chunkrotoutnobcstm403l_0_[1] chunkrotoutvecnobcstm403l_0_rep[1]
+ vcc vss i0mbfn000ab1n21x5
Xbuffer_int[0] chunkrotoutnobcstm403l_0_[0] chunkrotoutintnobcstm403l_0_rep[0] vcc
+ vss i0mbfn000ab1n21x5
Xbuffer_int[1] chunkrotoutnobcstm403l_0_[1] chunkrotoutintnobcstm403l_0_rep[1] vcc
+ vss i0mbfn000ab1n21x5
Xbuffer_int[2] chunkrotoutnobcstm403l_1_[2] chunkrotoutintnobcstm403l_1_rep[0] vcc
+ vss i0mbfn000ab1n21x5
Xbuffer_int[3] chunkrotoutnobcstm403l_1_[3] chunkrotoutintnobcstm403l_1_rep[1] vcc
+ vss i0mbfn000ab1n21x5
Xgnac0 unaligndatl1am403l[1][0] vcc vss i0mydp122ub1n00x5
Xgnac1 unaligndatl1am403l[1][1] vcc vss i0mydp122ub1n00x5
Xgnac2 unaligndatl1am403l[2][0] vcc vss i0mydp122ub1n00x5
Xgnac4 unaligndatl1am403l[3][0] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcu_rota_2bit chunk0sel_not[1] chunk0sel_not[0] chunk1sel_not[1] chunk1sel_not[0]
+ chunkrotoutintnobcstm403l_0_rep[1] chunkrotoutintnobcstm403l_0_rep[0] chunkrotoutintnobcstm403l_1_rep[1]
+ chunkrotoutintnobcstm403l_1_rep[0] chunkrotoutvecnobcstm403l_0_rep[1] chunkrotoutvecnobcstm403l_0_rep[0]
+ chunkrotoutvecnobcstm403l_1_rep[1] chunkrotoutvecnobcstm403l_1_rep[0] unaligndatl1am403l[0][1]
+ unaligndatl1am403l[0][0] unaligndatl1am403l[1][1] unaligndatl1am403l[1][0] unaligndatl1am403l[2][1]
+ unaligndatl1am403l[2][0] unaligndatl1am403l[3][1] unaligndatl1am403l[3][0] vcc
+ vss
Xgnac3 unaligndatl1am403l[2][0] vcc vss i0mydp122ub1n00x5
Xiunaligned_0_23_[1] unaligndatl1am403l[1][1] chunk0sel_not[1] unaligndatl1am403l[3][1]
+ chunk0sel_rep[1] unaligned_0_23_[1] vcc vss i0maoi022ab1n06x5
Xiunaligned_0_23_0[1] unaligndatl1am403l[2][1] chunk1sel_not[1] unaligndatl1am403l[0][1]
+ chunk1sel_rep[1] unaligned_1_30_[1] vcc vss i0maoi022ab1n06x5
Xiunaligned_0_01_0[1] unaligndatl1am403l[1][1] chunk1sel_not[1] unaligndatl1am403l[3][1]
+ chunk1sel_rep[1] unaligned_1_12_[1] vcc vss i0maoi022ab1n06x5
Xiunaligned_0_[1] unaligned_0_01_[1] chunk0sel_not[0] unaligned_0_23_[1] chunk0sel_rep[0]
+ chunkrotoutnobcstm403l__0_[1] vcc vss i0maoi022ab1n09x5
Xiunaligned_0_0[1] unaligned_1_12_[1] chunk1sel_not[0] unaligned_1_30_[1] chunk1sel_rep[0]
+ chunkrotoutnobcstm403l__1_[1] vcc vss i0maoi022ab1n09x5
Xiunaligned_0_0[0] unaligned_1_12_[0] chunk1sel_not[0] unaligned_1_30_[0] chunk1sel_rep[0]
+ chunkrotoutnobcstm403l__1_[0] vcc vss i0maoi022ab1n09x5
Xivec1[0] chunkrotoutnobcstm403l__1_[0] chunkrotoutvecnobcstm403l_1_rep[0] vcc vss i0mbfn000ab1n21x5
Xiunaligned_0_01_[1] unaligndatl1am403l[0][1] chunk0sel_not[1] unaligndatl1am403l[2][1]
+ chunk0sel_rep[1] unaligned_0_01_[1] vcc vss i0maoi022ab1n06x5
Xivec0[0] chunkrotoutnobcstm403l__0_[0] chunkrotoutvecnobcstm403l_0_rep[0] vcc vss i0mbfn000ab1n21x5
Xi5_int0[1] chunkrotoutnobcstm403l__0_[1] chunkrotoutintnobcstm403l_0_rep[1] vcc
+ vss i0mbfn000ab1n21x5
Xirep[0] chunk0sel_not[0] chunk0sel_rep[0] vcc vss i0minv000ab1n06x5
Xi5_int0[0] chunkrotoutnobcstm403l__0_[0] chunkrotoutintnobcstm403l_0_rep[0] vcc
+ vss i0mbfn000ab1n21x5
Xi5_int1[1] chunkrotoutnobcstm403l__1_[1] chunkrotoutintnobcstm403l_1_rep[1] vcc
+ vss i0mbfn000ab1n21x5
Xiunaligned_0_23_0[0] unaligndatl1am403l[2][0] chunk1sel_not[1] unaligndatl1am403l[0][0]
+ chunk1sel_rep[1] unaligned_1_30_[0] vcc vss i0maoi022ab1n06x5
Xirep[1] chunk0sel_not[1] chunk0sel_rep[1] vcc vss i0minv000ab1n06x5
Xiunaligned_0_01_[0] unaligndatl1am403l[0][0] chunk0sel_not[1] unaligndatl1am403l[2][0]
+ chunk0sel_rep[1] unaligned_0_01_[0] vcc vss i0maoi022ab1n06x5
Xi5_int1[0] chunkrotoutnobcstm403l__1_[0] chunkrotoutintnobcstm403l_1_rep[0] vcc
+ vss i0mbfn000ab1n21x5
Xivec1[1] chunkrotoutnobcstm403l__1_[1] chunkrotoutvecnobcstm403l_1_rep[1] vcc vss i0mbfn000ab1n21x5
Xiunaligned_0_23_[0] unaligndatl1am403l[1][0] chunk0sel_not[1] unaligndatl1am403l[3][0]
+ chunk0sel_rep[1] unaligned_0_23_[0] vcc vss i0maoi022ab1n06x5
Xirep0[1] chunk1sel_not[1] chunk1sel_rep[1] vcc vss i0minv000ab1n06x5
Xiunaligned_0_[0] unaligned_0_01_[0] chunk0sel_not[0] unaligned_0_23_[0] chunk0sel_rep[0]
+ chunkrotoutnobcstm403l__0_[0] vcc vss i0maoi022ab1n09x5
Xirep0[0] chunk1sel_not[0] chunk1sel_rep[0] vcc vss i0minv000ab1n06x5
Xivec0[1] chunkrotoutnobcstm403l__0_[1] chunkrotoutvecnobcstm403l_0_rep[1] vcc vss i0mbfn000ab1n21x5
Xiunaligned_0_01_0[0] unaligndatl1am403l[1][0] chunk1sel_not[1] unaligndatl1am403l[3][0]
+ chunk1sel_rep[1] unaligned_1_12_[0] vcc vss i0maoi022ab1n06x5
Xgnac0 unaligndatl1am403l[3][0] vcc vss i0mydp122ub1n00x5
Xgnac1 unaligndatl1am403l[3][1] vcc vss i0mydp122ub1n00x5
Xgnac2 unaligndatl1am403l[0][1] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcu_rotd_2bit chunkrotctrlm403l_sel0[3] chunkrotctrlm403l_sel0[2] chunkrotctrlm403l_sel0[1]
+ chunkrotctrlm403l_sel0[0] chunkrotctrlm403l_sel1[3] chunkrotctrlm403l_sel1[2]
+ chunkrotctrlm403l_sel1[1] chunkrotctrlm403l_sel1[0] chunkrotoutintnobcstm403l_0_rep[1]
+ chunkrotoutintnobcstm403l_0_rep[0] chunkrotoutintnobcstm403l_1_rep[1] chunkrotoutintnobcstm403l_1_rep[0]
+ chunkrotoutvecnobcstm403l_0_rep[1] chunkrotoutvecnobcstm403l_0_rep[0] chunkrotoutvecnobcstm403l_1_rep[1]
+ chunkrotoutvecnobcstm403l_1_rep[0] rotrdportbrotdm403l[3] rotrdportbrotdm403l[2]
+ rotrdportbrotdm403l[1] rotrdportbrotdm403l[0] unaligndatl1am403l[0][1] unaligndatl1am403l[0][0]
+ unaligndatl1am403l[1][1] unaligndatl1am403l[1][0] unaligndatl1am403l[2][1] unaligndatl1am403l[2][0]
+ unaligndatl1am403l[3][1] unaligndatl1am403l[3][0] unaligndatl1bm403l[0][1] unaligndatl1bm403l[0][0]
+ unaligndatl1bm403l[1][1] unaligndatl1bm403l[1][0] unaligndatl1bm403l[2][1] unaligndatl1bm403l[2][0]
+ unaligndatl1bm403l[3][1] unaligndatl1bm403l[3][0] vcc vss
Xgnac7 unaligndatl1bm403l[1][0] vcc vss i0mydp122ub1n00x5
Xi2_mux3 unalignchun2bit#[1] chunkrotctrlm403l_sel1[2] unalignchun3bit#[1] chunkrotctrlm403l_sel1[3]
+ muxstage_b_1_[1] vcc vss i0maoi022ab1n06x5
Xi10_mux2 unalignchun0bit#[0] chunkrotctrlm403l_sel1[0] unalignchun1bit#[0] chunkrotctrlm403l_sel1[1]
+ muxstage_a_1_[0] vcc vss i0maoi022ab1n06x5
Xi8_mux0 unalignchun2bit#[1] chunkrotctrlm403l_sel0[2] unalignchun3bit#[1] chunkrotctrlm403l_sel0[3]
+ muxstage_b_0_[0] vcc vss i0maoi022ab1n06x5
Xi5_mux1 unalignchun2bit#[0] chunkrotctrlm403l_sel0[2] unalignchun3bit#[0] chunkrotctrlm403l_sel0[3]
+ muxstage_b_0_[1] vcc vss i0maoi022ab1n06x5
Xi4_mux2 unalignchun2bit#[0] chunkrotctrlm403l_sel1[2] unalignchun3bit#[0] chunkrotctrlm403l_sel1[3]
+ muxstage_b_1_[0] vcc vss i0maoi022ab1n06x5
Xi7_mux1 unalignchun0bit#[0] chunkrotctrlm403l_sel0[0] unalignchun1bit#[0] chunkrotctrlm403l_sel0[1]
+ muxstage_a_0_[0] vcc vss i0maoi022ab1n06x5
Xmuxout_0_[0] muxstage_a_0_[0] muxstage_b_0_[1] chunkrotoutnobcstm403l_0_[0] vcc
+ vss i0mnand02ab1n12x5
Xmuxout_0_[1] muxstage_a_0_[1] muxstage_b_0_[0] chunkrotoutnobcstm403l_0_[1] vcc
+ vss i0mnand02ab1n12x5
Xmuxout_1_[0] muxstage_a_1_[0] muxstage_b_1_[0] chunkrotoutnobcstm403l_1_[0] vcc
+ vss i0mnand02ab1n12x5
Xmuxout_1_[1] muxstage_a_1_[1] muxstage_b_1_[1] chunkrotoutnobcstm403l_1_[1] vcc
+ vss i0mnand02ab1n12x5
Xmux2_b[2] unaligndatl1am403l[2][1] unaligndatl1bm403l[2][1] unalignchun2bit#[1]
+ rotrdportbrotdm403l[2] vcc vss i0mmdn022ab1n06x5
Xmux2_b[3] unaligndatl1am403l[3][1] unaligndatl1bm403l[3][1] unalignchun3bit#[1]
+ rotrdportbrotdm403l[3] vcc vss i0mmdn022ab1n06x5
Xmux2_b[1] unaligndatl1am403l[1][1] unaligndatl1bm403l[1][1] unalignchun1bit#[1]
+ rotrdportbrotdm403l[1] vcc vss i0mmdn022ab1n06x5
Xmux2_b[0] unaligndatl1am403l[0][1] unaligndatl1bm403l[0][1] unalignchun0bit#[1]
+ rotrdportbrotdm403l[0] vcc vss i0mmdn022ab1n06x5
Xmux2_a[1] unaligndatl1am403l[1][0] unaligndatl1bm403l[1][0] unalignchun1bit#[0]
+ rotrdportbrotdm403l[1] vcc vss i0mmdn022ab1n06x5
Xmux2_a[3] unaligndatl1am403l[3][0] unaligndatl1bm403l[3][0] unalignchun3bit#[0]
+ rotrdportbrotdm403l[3] vcc vss i0mmdn022ab1n06x5
Xmux2_a[2] unaligndatl1am403l[2][0] unaligndatl1bm403l[2][0] unalignchun2bit#[0]
+ rotrdportbrotdm403l[2] vcc vss i0mmdn022ab1n06x5
Xmux2_a[0] unaligndatl1am403l[0][0] unaligndatl1bm403l[0][0] unalignchun0bit#[0]
+ rotrdportbrotdm403l[0] vcc vss i0mmdn022ab1n06x5
Xi1_mux3 unalignchun0bit#[1] chunkrotctrlm403l_sel1[0] unalignchun1bit#[1] chunkrotctrlm403l_sel1[1]
+ muxstage_a_1_[1] vcc vss i0maoi022ab1n06x5
Xi9_mux0 unalignchun0bit#[1] chunkrotctrlm403l_sel0[0] unalignchun1bit#[1] chunkrotctrlm403l_sel0[1]
+ muxstage_a_0_[1] vcc vss i0maoi022ab1n06x5
Xinverter_int_0_[0] chunkrotoutnobcstm403l_0_[0] chunkrotoutintnobcstm403l_0_rep[0]
+ vcc vss i0minv000ab1n21x5
Xinverter_int_0_[1] chunkrotoutnobcstm403l_0_[1] chunkrotoutintnobcstm403l_0_rep[1]
+ vcc vss i0minv000ab1n21x5
Xinverter_int_1_[0] chunkrotoutnobcstm403l_1_[0] chunkrotoutintnobcstm403l_1_rep[0]
+ vcc vss i0minv000ab1n21x5
Xinverter_int_1_[1] chunkrotoutnobcstm403l_1_[1] chunkrotoutintnobcstm403l_1_rep[1]
+ vcc vss i0minv000ab1n21x5
Xinverter_vec_0_[0] chunkrotoutnobcstm403l_0_[0] chunkrotoutvecnobcstm403l_0_rep[0]
+ vcc vss i0minv000ab1n21x5
Xinverter_vec_0_[1] chunkrotoutnobcstm403l_0_[1] chunkrotoutvecnobcstm403l_0_rep[1]
+ vcc vss i0minv000ab1n21x5
Xinverter_vec_1_[0] chunkrotoutnobcstm403l_1_[0] chunkrotoutvecnobcstm403l_1_rep[0]
+ vcc vss i0minv000ab1n21x5
Xinverter_vec_1_[1] chunkrotoutnobcstm403l_1_[1] chunkrotoutvecnobcstm403l_1_rep[1]
+ vcc vss i0minv000ab1n21x5
Xgnac2 unaligndatl1bm403l[0][0] vcc vss i0mydp122ub1n00x5
Xgnac5 unaligndatl1am403l[0][0] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcchunkrotd_spare_container vcc vss
Xspare_176 vcc vss i0mqsnfs4ab1d06x5
Xspare_184 vcc vss i0mqsnls3ab1d06x5
Xspare_183 vcc vss i0mqsnls3ab1d06x5
Xspare_182 vcc vss i0mqsnin1ab1n18x5
Xspare_181 vcc vss i0mqsnin1ab1n18x5
Xspare_180 vcc vss i0mqsnbf1ab1n18x5
Xspare_179 vcc vss i0mqsnbf1ab1n18x5
Xspare_175 vcc vss i0mqsnfs4ab1d06x5
Xspare_174 vcc vss i0mqsnca4ab1n06x5
Xspare_173 vcc vss i0mqsnca4ab1n06x5
Xspare_172 vcc vss i0mqsnco4ab1n06x5
Xspare_171 vcc vss i0mqsnco4ab1n06x5
Xspare_170 vcc vss i0mqsnno3ab1n06x5
Xspare_169 vcc vss i0mqsnno3ab1n06x5
Xspare_168 vcc vss i0mqsnna3ab1n06x5
Xspare_167 vcc vss i0mqsnna3ab1n06x5
Xspare_166 vcc vss i0mqsnin1ab1n12x5
Xspare_165 vcc vss i0mqsnin1ab1n12x5
Xspare_164 vcc vss i0mqsnbf1ab1n12x5
Xspare_163 vcc vss i0mqsnbf1ab1n12x5
.ENDS

.SUBCKT dcchunkrotd_dcap_container vcc vss
Xdcapcell_3764 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3755 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3752 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3751 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3749 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3747 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3746 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3745 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3742 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3740 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3739 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3738 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3737 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3735 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3734 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3733 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3689 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3688 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3687 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3686 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3685 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3684 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3683 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3682 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3681 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3680 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3679 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3678 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3677 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3676 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3675 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3674 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3673 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3672 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3671 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3670 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3669 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3667 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3666 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3664 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3663 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3662 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3661 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3660 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3659 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3658 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3657 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3656 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3655 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3654 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3653 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3652 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3651 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3650 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3649 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3648 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3647 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3646 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3645 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3644 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3643 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3642 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3641 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3640 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3639 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3638 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3637 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3636 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3635 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3634 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3633 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3632 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3631 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3630 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3628 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3627 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3626 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3625 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3624 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3623 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3622 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3621 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3620 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3619 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3618 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3617 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3616 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3615 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3614 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3613 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3612 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3611 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3610 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3609 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3608 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3607 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3606 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3605 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3604 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3603 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3602 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3601 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3600 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3599 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3598 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3597 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3596 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3595 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3594 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3593 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3592 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3591 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3590 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3589 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3588 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3587 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3586 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3585 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3584 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3583 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3582 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3580 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3579 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3578 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3577 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3575 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3574 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3573 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3572 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3570 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3569 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3568 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3567 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3566 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3565 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3564 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3563 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3562 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3561 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3560 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3559 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3558 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3557 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3556 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3555 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3554 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3553 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3552 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3551 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3550 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3549 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3548 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3547 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3546 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3545 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3544 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3543 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3542 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3541 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3540 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3539 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3538 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3535 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3534 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3533 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3532 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3531 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3530 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3529 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3528 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3527 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3526 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3525 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3524 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3523 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3522 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3520 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3519 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3518 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3517 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3516 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3515 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3514 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3513 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3512 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3510 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3509 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3508 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3507 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3505 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3503 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3502 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3501 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3500 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3499 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3498 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3497 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3496 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3495 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3494 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3493 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3492 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3491 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3490 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3489 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3487 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3486 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3485 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3484 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3483 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3482 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3481 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3480 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3479 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3478 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3477 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3476 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3475 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3474 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3473 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3472 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3471 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3470 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3469 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3468 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3467 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3466 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3465 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3464 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3463 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3460 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3459 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3457 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3456 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3455 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3454 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3452 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3451 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3450 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3449 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3448 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3447 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3446 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3445 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3444 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3443 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3442 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3441 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3440 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3439 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3438 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3437 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3436 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3435 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3434 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3433 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3431 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3430 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3429 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3428 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3427 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3426 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3425 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3424 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3422 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3421 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3419 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3417 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3416 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3415 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3414 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3412 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3411 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3410 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3409 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3408 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3407 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3406 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3405 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3404 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3402 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3401 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3400 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3399 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3398 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3397 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3396 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3395 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3394 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3393 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3391 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3390 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3389 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3388 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3387 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3386 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3385 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3384 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3383 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3382 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3381 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3380 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3379 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3378 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3377 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3376 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3375 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3374 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3373 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3372 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3371 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3370 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3369 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3368 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3367 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3366 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3365 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3364 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3363 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3362 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3361 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3360 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3359 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3358 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3357 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3356 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3355 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3354 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3353 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3352 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3351 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3350 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3349 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3348 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3347 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3346 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3345 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3344 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3343 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3342 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3341 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3340 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3339 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3338 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3337 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3336 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3335 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3333 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3332 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3330 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3329 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3328 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3327 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3326 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3325 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3324 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3323 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3322 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3321 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3319 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3318 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3317 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3316 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3315 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3314 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3313 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3312 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3310 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3309 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3308 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3307 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3306 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3305 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3304 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3303 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3302 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3301 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3300 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3299 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3298 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3297 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3296 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3295 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3294 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3292 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3291 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3290 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3289 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3288 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3286 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3285 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3284 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3283 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3282 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3281 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3280 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3279 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3278 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3277 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3276 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3275 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3274 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3273 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3272 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3271 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3270 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3269 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3268 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3267 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3266 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3265 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3263 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3262 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3261 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3260 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3259 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3258 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3257 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3256 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3255 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3254 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3253 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3252 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3251 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3250 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3249 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3248 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3247 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3246 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3245 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3244 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3243 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3242 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3241 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3240 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3239 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3238 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3237 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3236 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3235 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3234 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3232 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3231 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3230 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3229 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3228 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3227 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3226 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3225 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3224 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3223 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3222 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3221 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3220 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3219 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3218 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3217 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3216 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3215 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3214 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3213 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3212 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3211 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3210 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3209 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3208 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3207 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3206 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3205 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3204 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3203 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3202 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3201 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3200 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3199 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3198 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3197 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3196 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3195 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3194 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3193 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3192 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3191 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3190 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3189 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3187 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3186 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3185 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3184 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3183 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3182 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3181 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3180 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3179 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3178 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3177 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3176 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3175 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3174 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3173 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3172 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3171 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3170 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3169 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3168 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3167 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3166 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3165 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3164 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3163 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3162 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3161 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3160 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3159 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3158 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3157 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3156 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3155 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3154 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3153 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3152 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3151 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3150 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_3149 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3148 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3147 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3145 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3144 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3143 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3142 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3141 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3139 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3138 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3137 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3136 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3135 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3133 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3132 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3131 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3130 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3129 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3128 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3127 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3126 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3125 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3124 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3123 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3122 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3120 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3119 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3117 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3116 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3115 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3114 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3113 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3112 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3111 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3110 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3109 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3107 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3106 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3105 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3104 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3103 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3101 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3100 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3099 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_3098 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3096 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3095 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_3094 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3093 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3091 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3089 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3088 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_3087 vcc vss i0mzdcf33ub1n08x5
.ENDS

.SUBCKT dcchunkrotd_bonus_container vcc vss
Xbonus_188 vcc vss i0mqbnno2bc1d20x5
Xbonus_187 vcc vss i0mqbnna2bc1d20x5
Xbonus_186 vcc vss i0mqbnbf2bc1d30x5
.ENDS

.SUBCKT dcu_rotc_byte chunkrotctrlm403l_0_[1] chunkrotctrlm403l_0_[0] chunkrotctrlm403l_1_[1]
+ chunkrotctrlm403l_1_[0] chunkrotoutintnobcstm403l_2_0_[7] chunkrotoutintnobcstm403l_2_0_[6]
+ chunkrotoutintnobcstm403l_2_0_[5] chunkrotoutintnobcstm403l_2_0_[4] chunkrotoutintnobcstm403l_2_0_[3]
+ chunkrotoutintnobcstm403l_2_0_[2] chunkrotoutintnobcstm403l_2_0_[1] chunkrotoutintnobcstm403l_2_0_[0]
+ chunkrotoutintnobcstm403l_2_1_[7] chunkrotoutintnobcstm403l_2_1_[6] chunkrotoutintnobcstm403l_2_1_[5]
+ chunkrotoutintnobcstm403l_2_1_[4] chunkrotoutintnobcstm403l_2_1_[3] chunkrotoutintnobcstm403l_2_1_[2]
+ chunkrotoutintnobcstm403l_2_1_[1] chunkrotoutintnobcstm403l_2_1_[0] chunkrotoutvecnobcstm403l_2_0_[7]
+ chunkrotoutvecnobcstm403l_2_0_[6] chunkrotoutvecnobcstm403l_2_0_[5] chunkrotoutvecnobcstm403l_2_0_[4]
+ chunkrotoutvecnobcstm403l_2_0_[3] chunkrotoutvecnobcstm403l_2_0_[2] chunkrotoutvecnobcstm403l_2_0_[1]
+ chunkrotoutvecnobcstm403l_2_0_[0] chunkrotoutvecnobcstm403l_2_1_[7] chunkrotoutvecnobcstm403l_2_1_[6]
+ chunkrotoutvecnobcstm403l_2_1_[5] chunkrotoutvecnobcstm403l_2_1_[4] chunkrotoutvecnobcstm403l_2_1_[3]
+ chunkrotoutvecnobcstm403l_2_1_[2] chunkrotoutvecnobcstm403l_2_1_[1] chunkrotoutvecnobcstm403l_2_1_[0]
+ unaligndatl1bm403l[0][7] unaligndatl1bm403l[0][6] unaligndatl1bm403l[0][5] unaligndatl1bm403l[0][4]
+ unaligndatl1bm403l[0][3] unaligndatl1bm403l[0][2] unaligndatl1bm403l[0][1] unaligndatl1bm403l[0][0]
+ unaligndatl1bm403l[1][7] unaligndatl1bm403l[1][6] unaligndatl1bm403l[1][5] unaligndatl1bm403l[1][4]
+ unaligndatl1bm403l[1][3] unaligndatl1bm403l[1][2] unaligndatl1bm403l[1][1] unaligndatl1bm403l[1][0]
+ unaligndatl1bm403l[2][7] unaligndatl1bm403l[2][6] unaligndatl1bm403l[2][5] unaligndatl1bm403l[2][4]
+ unaligndatl1bm403l[2][3] unaligndatl1bm403l[2][2] unaligndatl1bm403l[2][1] unaligndatl1bm403l[2][0]
+ unaligndatl1bm403l[3][7] unaligndatl1bm403l[3][6] unaligndatl1bm403l[3][5] unaligndatl1bm403l[3][4]
+ unaligndatl1bm403l[3][3] unaligndatl1bm403l[3][2] unaligndatl1bm403l[3][1] unaligndatl1bm403l[3][0]
+ vcc vss
Xchunk1_up[1] chunkrotctrlm403l_1_[1] chunk1not_up[1] vcc vss i0minv000ab1n18x5
Xchunk1_up[0] chunkrotctrlm403l_1_[0] chunk1not_up[0] vcc vss i0minv000ab1n18x5
Xchunk1_dn[1] chunkrotctrlm403l_1_[1] chunk1not_dn[1] vcc vss i0minv000ab1n18x5
Xchunk1_dn[0] chunkrotctrlm403l_1_[0] chunk1not_dn[0] vcc vss i0minv000ab1n18x5
Xchunk0_up[1] chunkrotctrlm403l_0_[1] chunk0not_up[1] vcc vss i0minv000ab1n18x5
Xchunk0_up[0] chunkrotctrlm403l_0_[0] chunk0not_up[0] vcc vss i0minv000ab1n18x5
Xchunk0_dn[1] chunkrotctrlm403l_0_[1] chunk0not_dn[1] vcc vss i0minv000ab1n18x5
Xchunk0_dn[0] chunkrotctrlm403l_0_[0] chunk0not_dn[0] vcc vss i0minv000ab1n18x5
Xidcu_rota_2bit[0] chunk0not_dn[1] chunk0not_dn[0] chunk1not_dn[1] chunk1not_dn[0]
+ chunkrotoutintnobcstm403l_2_0_[1] chunkrotoutintnobcstm403l_2_0_[0] chunkrotoutintnobcstm403l_2_1_[1]
+ chunkrotoutintnobcstm403l_2_1_[0] chunkrotoutvecnobcstm403l_2_0_[1] chunkrotoutvecnobcstm403l_2_0_[0]
+ chunkrotoutvecnobcstm403l_2_1_[1] chunkrotoutvecnobcstm403l_2_1_[0] unaligndatl1bm403l[0][1]
+ unaligndatl1bm403l[0][0] unaligndatl1bm403l[1][1] unaligndatl1bm403l[1][0] unaligndatl1bm403l[2][1]
+ unaligndatl1bm403l[2][0] unaligndatl1bm403l[3][1] unaligndatl1bm403l[3][0] vcc
+ vss dcu_rotc_2bit
Xidcu_rota_2bit[1] chunk0not_dn[1] chunk0not_dn[0] chunk1not_dn[1] chunk1not_dn[0]
+ chunkrotoutintnobcstm403l_2_0_[3] chunkrotoutintnobcstm403l_2_0_[2] chunkrotoutintnobcstm403l_2_1_[3]
+ chunkrotoutintnobcstm403l_2_1_[2] chunkrotoutvecnobcstm403l_2_0_[3] chunkrotoutvecnobcstm403l_2_0_[2]
+ chunkrotoutvecnobcstm403l_2_1_[3] chunkrotoutvecnobcstm403l_2_1_[2] unaligndatl1bm403l[0][3]
+ unaligndatl1bm403l[0][2] unaligndatl1bm403l[1][3] unaligndatl1bm403l[1][2] unaligndatl1bm403l[2][3]
+ unaligndatl1bm403l[2][2] unaligndatl1bm403l[3][3] unaligndatl1bm403l[3][2] vcc
+ vss dcu_rotc_2bit
Xidcu_rota_2bit[2] chunk0not_up[1] chunk0not_up[0] chunk1not_up[1] chunk1not_up[0]
+ chunkrotoutintnobcstm403l_2_0_[5] chunkrotoutintnobcstm403l_2_0_[4] chunkrotoutintnobcstm403l_2_1_[5]
+ chunkrotoutintnobcstm403l_2_1_[4] chunkrotoutvecnobcstm403l_2_0_[5] chunkrotoutvecnobcstm403l_2_0_[4]
+ chunkrotoutvecnobcstm403l_2_1_[5] chunkrotoutvecnobcstm403l_2_1_[4] unaligndatl1bm403l[0][5]
+ unaligndatl1bm403l[0][4] unaligndatl1bm403l[1][5] unaligndatl1bm403l[1][4] unaligndatl1bm403l[2][5]
+ unaligndatl1bm403l[2][4] unaligndatl1bm403l[3][5] unaligndatl1bm403l[3][4] vcc
+ vss dcu_rotc_2bit
Xidcu_rota_2bit[3] chunk0not_up[1] chunk0not_up[0] chunk1not_up[1] chunk1not_up[0]
+ chunkrotoutintnobcstm403l_2_0_[7] chunkrotoutintnobcstm403l_2_0_[6] chunkrotoutintnobcstm403l_2_1_[7]
+ chunkrotoutintnobcstm403l_2_1_[6] chunkrotoutvecnobcstm403l_2_0_[7] chunkrotoutvecnobcstm403l_2_0_[6]
+ chunkrotoutvecnobcstm403l_2_1_[7] chunkrotoutvecnobcstm403l_2_1_[6] unaligndatl1bm403l[0][7]
+ unaligndatl1bm403l[0][6] unaligndatl1bm403l[1][7] unaligndatl1bm403l[1][6] unaligndatl1bm403l[2][7]
+ unaligndatl1bm403l[2][6] unaligndatl1bm403l[3][7] unaligndatl1bm403l[3][6] vcc
+ vss dcu_rotc_2bit
Xgnac0 chunkrotctrlm403l_1_[1] vcc vss i0mydp122ub1n00x5
Xgnac1 chunkrotctrlm403l_0_[0] vcc vss i0mydp122ub1n00x5
Xgnac2 chunkrotctrlm403l_1_[0] vcc vss i0mydp122ub1n00x5
Xgnac3 chunkrotctrlm403l_0_[1] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcu_rota_byte chunkrotctrlm403l_0_[1] chunkrotctrlm403l_0_[0] chunkrotctrlm403l_1_[1]
+ chunkrotctrlm403l_1_[0] chunkrotoutintnobcstm403l_0_[7] chunkrotoutintnobcstm403l_0_[6]
+ chunkrotoutintnobcstm403l_0_[5] chunkrotoutintnobcstm403l_0_[4] chunkrotoutintnobcstm403l_0_[3]
+ chunkrotoutintnobcstm403l_0_[2] chunkrotoutintnobcstm403l_0_[1] chunkrotoutintnobcstm403l_0_[0]
+ chunkrotoutintnobcstm403l_1_[7] chunkrotoutintnobcstm403l_1_[6] chunkrotoutintnobcstm403l_1_[5]
+ chunkrotoutintnobcstm403l_1_[4] chunkrotoutintnobcstm403l_1_[3] chunkrotoutintnobcstm403l_1_[2]
+ chunkrotoutintnobcstm403l_1_[1] chunkrotoutintnobcstm403l_1_[0] chunkrotoutvecnobcstm403l_0_[7]
+ chunkrotoutvecnobcstm403l_0_[6] chunkrotoutvecnobcstm403l_0_[5] chunkrotoutvecnobcstm403l_0_[4]
+ chunkrotoutvecnobcstm403l_0_[3] chunkrotoutvecnobcstm403l_0_[2] chunkrotoutvecnobcstm403l_0_[1]
+ chunkrotoutvecnobcstm403l_0_[0] chunkrotoutvecnobcstm403l_1_[7] chunkrotoutvecnobcstm403l_1_[6]
+ chunkrotoutvecnobcstm403l_1_[5] chunkrotoutvecnobcstm403l_1_[4] chunkrotoutvecnobcstm403l_1_[3]
+ chunkrotoutvecnobcstm403l_1_[2] chunkrotoutvecnobcstm403l_1_[1] chunkrotoutvecnobcstm403l_1_[0]
+ unaligndatl1am403l[0][7] unaligndatl1am403l[0][6] unaligndatl1am403l[0][5] unaligndatl1am403l[0][4]
+ unaligndatl1am403l[0][3] unaligndatl1am403l[0][2] unaligndatl1am403l[0][1] unaligndatl1am403l[0][0]
+ unaligndatl1am403l[1][7] unaligndatl1am403l[1][6] unaligndatl1am403l[1][5] unaligndatl1am403l[1][4]
+ unaligndatl1am403l[1][3] unaligndatl1am403l[1][2] unaligndatl1am403l[1][1] unaligndatl1am403l[1][0]
+ unaligndatl1am403l[2][7] unaligndatl1am403l[2][6] unaligndatl1am403l[2][5] unaligndatl1am403l[2][4]
+ unaligndatl1am403l[2][3] unaligndatl1am403l[2][2] unaligndatl1am403l[2][1] unaligndatl1am403l[2][0]
+ unaligndatl1am403l[3][7] unaligndatl1am403l[3][6] unaligndatl1am403l[3][5] unaligndatl1am403l[3][4]
+ unaligndatl1am403l[3][3] unaligndatl1am403l[3][2] unaligndatl1am403l[3][1] unaligndatl1am403l[3][0]
+ vcc vss
Xchunk1not_up[1] chunkrotctrlm403l_1_[1] chunk1not__up[1] vcc vss i0minv000ab1n18x5
Xchunk1not_up[0] chunkrotctrlm403l_1_[0] chunk1not__up[0] vcc vss i0minv000ab1n18x5
Xchunk1not_dn[1] chunkrotctrlm403l_1_[1] chunk1not__dn[1] vcc vss i0minv000ab1n18x5
Xchunk1not_dn[0] chunkrotctrlm403l_1_[0] chunk1not__dn[0] vcc vss i0minv000ab1n18x5
Xchunk0not_up[1] chunkrotctrlm403l_0_[1] chunk0not__up[1] vcc vss i0minv000ab1n18x5
Xchunk0not_dn[1] chunkrotctrlm403l_0_[1] chunk0not__dn[1] vcc vss i0minv000ab1n18x5
Xchunk0not_up[0] chunkrotctrlm403l_0_[0] chunk0not__up[0] vcc vss i0minv000ab1n18x5
Xchunk0not_dn[0] chunkrotctrlm403l_0_[0] chunk0not__dn[0] vcc vss i0minv000ab1n18x5
Xidcu_rota_2bit[2] chunk0not__up[1] chunk0not__up[0] chunk1not__up[1] chunk1not__up[0]
+ chunkrotoutintnobcstm403l_0_[5] chunkrotoutintnobcstm403l_0_[4] chunkrotoutintnobcstm403l_1_[5]
+ chunkrotoutintnobcstm403l_1_[4] chunkrotoutvecnobcstm403l_0_[5] chunkrotoutvecnobcstm403l_0_[4]
+ chunkrotoutvecnobcstm403l_1_[5] chunkrotoutvecnobcstm403l_1_[4] unaligndatl1am403l[0][5]
+ unaligndatl1am403l[0][4] unaligndatl1am403l[1][5] unaligndatl1am403l[1][4] unaligndatl1am403l[2][5]
+ unaligndatl1am403l[2][4] unaligndatl1am403l[3][5] unaligndatl1am403l[3][4] vcc
+ vss dcu_rota_2bit
Xidcu_rota_2bit[1] chunk0not__dn[1] chunk0not__dn[0] chunk1not__dn[1] chunk1not__dn[0]
+ chunkrotoutintnobcstm403l_0_[3] chunkrotoutintnobcstm403l_0_[2] chunkrotoutintnobcstm403l_1_[3]
+ chunkrotoutintnobcstm403l_1_[2] chunkrotoutvecnobcstm403l_0_[3] chunkrotoutvecnobcstm403l_0_[2]
+ chunkrotoutvecnobcstm403l_1_[3] chunkrotoutvecnobcstm403l_1_[2] unaligndatl1am403l[0][3]
+ unaligndatl1am403l[0][2] unaligndatl1am403l[1][3] unaligndatl1am403l[1][2] unaligndatl1am403l[2][3]
+ unaligndatl1am403l[2][2] unaligndatl1am403l[3][3] unaligndatl1am403l[3][2] vcc
+ vss dcu_rota_2bit
Xidcu_rota_2bit[3] chunk0not__up[1] chunk0not__up[0] chunk1not__up[1] chunk1not__up[0]
+ chunkrotoutintnobcstm403l_0_[7] chunkrotoutintnobcstm403l_0_[6] chunkrotoutintnobcstm403l_1_[7]
+ chunkrotoutintnobcstm403l_1_[6] chunkrotoutvecnobcstm403l_0_[7] chunkrotoutvecnobcstm403l_0_[6]
+ chunkrotoutvecnobcstm403l_1_[7] chunkrotoutvecnobcstm403l_1_[6] unaligndatl1am403l[0][7]
+ unaligndatl1am403l[0][6] unaligndatl1am403l[1][7] unaligndatl1am403l[1][6] unaligndatl1am403l[2][7]
+ unaligndatl1am403l[2][6] unaligndatl1am403l[3][7] unaligndatl1am403l[3][6] vcc
+ vss dcu_rota_2bit
Xidcu_rota_2bit[0] chunk0not__dn[1] chunk0not__dn[0] chunk1not__dn[1] chunk1not__dn[0]
+ chunkrotoutintnobcstm403l_0_[1] chunkrotoutintnobcstm403l_0_[0] chunkrotoutintnobcstm403l_1_[1]
+ chunkrotoutintnobcstm403l_1_[0] chunkrotoutvecnobcstm403l_0_[1] chunkrotoutvecnobcstm403l_0_[0]
+ chunkrotoutvecnobcstm403l_1_[1] chunkrotoutvecnobcstm403l_1_[0] unaligndatl1am403l[0][1]
+ unaligndatl1am403l[0][0] unaligndatl1am403l[1][1] unaligndatl1am403l[1][0] unaligndatl1am403l[2][1]
+ unaligndatl1am403l[2][0] unaligndatl1am403l[3][1] unaligndatl1am403l[3][0] vcc
+ vss dcu_rota_2bit
Xgnac0 chunkrotctrlm403l_1_[0] vcc vss i0mydp122ub1n00x5
Xgnac1 chunkrotctrlm403l_0_[1] vcc vss i0mydp122ub1n00x5
Xgnac2 chunkrotctrlm403l_0_[0] vcc vss i0mydp122ub1n00x5
Xgnac3 chunkrotctrlm403l_1_[1] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcu_rotd_ctrl chunkrotctrlm403l0[1] chunkrotctrlm403l0[0] chunkrotctrlm403l1[1]
+ chunkrotctrlm403l1[0] chunkrotctrlm403l_sel0[3] chunkrotctrlm403l_sel0[2] chunkrotctrlm403l_sel0[1]
+ chunkrotctrlm403l_sel0[0] chunkrotctrlm403l_sel1[3] chunkrotctrlm403l_sel1[2]
+ chunkrotctrlm403l_sel1[1] chunkrotctrlm403l_sel1[0] rotrdportbrotbm403l[3] rotrdportbrotbm403l[2]
+ rotrdportbrotbm403l[1] rotrdportbrotbm403l[0] rotrdportbrotbm403l_rep[3] rotrdportbrotbm403l_rep[2]
+ rotrdportbrotbm403l_rep[1] rotrdportbrotbm403l_rep[0] vcc vss
Xidcrotdec2to4[1] chunkrotctrlm403l1[1] chunkrotctrlm403l1[0] chunkrotctrlm403l_sel1[3]
+ chunkrotctrlm403l_sel1[2] chunkrotctrlm403l_sel1[1] chunkrotctrlm403l_sel1[0]
+ vcc vss dcrotlddec2to4
Xidcrotdec2to4[0] chunkrotctrlm403l0[1] chunkrotctrlm403l0[0] chunkrotctrlm403l_sel0[3]
+ chunkrotctrlm403l_sel0[2] chunkrotctrlm403l_sel0[1] chunkrotctrlm403l_sel0[0]
+ vcc vss dcrotlddec2to4
Xi1[1] rotrdportbrotbm403l[1] rotrdportbrotbm403l_rep[1] vcc vss i0minv000ab1n24x5
Xi1[0] rotrdportbrotbm403l[0] rotrdportbrotbm403l_rep[0] vcc vss i0minv000ab1n24x5
Xi1[3] rotrdportbrotbm403l[3] rotrdportbrotbm403l_rep[3] vcc vss i0minv000ab1n24x5
Xi1[2] rotrdportbrotbm403l[2] rotrdportbrotbm403l_rep[2] vcc vss i0minv000ab1n24x5
Xgnac0 rotrdportbrotbm403l[0] vcc vss i0mydp122ub1n00x5
Xgnac1 rotrdportbrotbm403l[3] vcc vss i0mydp122ub1n00x5
Xgnac2 rotrdportbrotbm403l[2] vcc vss i0mydp122ub1n00x5
Xgnac3 rotrdportbrotbm403l[1] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcu_store_rot_ctrl clkanystorev4034ml_rep clksrstore4034ml_rep[3] clksrstore4034ml_rep[2]
+ clksrstore4034ml_rep[1] clksrstore4034ml_rep[0] fscan_clkungate_rep stchunkrotctrlm403h_0_[1]
+ stchunkrotctrlm403h_0_[0] stchunkrotctrlm403h_1_[1] stchunkrotctrlm403h_1_[0]
+ stchunkrotctrlm403h_2_[1] stchunkrotctrlm403h_2_[0] stchunkrotctrlm403h_3_[1]
+ stchunkrotctrlm403h_3_[0] stchunkrotctrlm403h_sel[15] stchunkrotctrlm403h_sel[14]
+ stchunkrotctrlm403h_sel[13] stchunkrotctrlm403h_sel[12] stchunkrotctrlm403h_sel[11]
+ stchunkrotctrlm403h_sel[10] stchunkrotctrlm403h_sel[9] stchunkrotctrlm403h_sel[8]
+ stchunkrotctrlm403h_sel[7] stchunkrotctrlm403h_sel[6] stchunkrotctrlm403h_sel[5]
+ stchunkrotctrlm403h_sel[4] stchunkrotctrlm403h_sel[3] stchunkrotctrlm403h_sel[2]
+ stchunkrotctrlm403h_sel[1] stchunkrotctrlm403h_sel[0] strotclkenm402l[3] strotclkenm402l[2]
+ strotclkenm402l[1] strotclkenm402l[0] vcc vss
Xidcrotdec2to4[3] stchunkrotctrlm403h_3_[1] stchunkrotctrlm403h_3_[0] stchunkrotctrlm403h_sel[15]
+ stchunkrotctrlm403h_sel[14] stchunkrotctrlm403h_sel[13] stchunkrotctrlm403h_sel[12]
+ vcc vss dcrotdec2to4_r2
Xidcrotdec2to4[2] stchunkrotctrlm403h_2_[1] stchunkrotctrlm403h_2_[0] stchunkrotctrlm403h_sel[11]
+ stchunkrotctrlm403h_sel[10] stchunkrotctrlm403h_sel[9] stchunkrotctrlm403h_sel[8]
+ vcc vss dcrotdec2to4_l
Xidcrotdec2to4[1] stchunkrotctrlm403h_1_[1] stchunkrotctrlm403h_1_[0] stchunkrotctrlm403h_sel[7]
+ stchunkrotctrlm403h_sel[6] stchunkrotctrlm403h_sel[5] stchunkrotctrlm403h_sel[4]
+ vcc vss dcrotdec2to4_r
Xidcrotdec2to4[0] stchunkrotctrlm403h_0_[1] stchunkrotctrlm403h_0_[0] stchunkrotctrlm403h_sel[3]
+ stchunkrotctrlm403h_sel[2] stchunkrotctrlm403h_sel[1] stchunkrotctrlm403h_sel[0]
+ vcc vss dcrotdec2to4_l2
Xi1[3] clkanystorev4034ml_rep clksrstore4034ml_rep[3] strotclkenm402l[3] fscan_clkungate_rep
+ vcc vss i0mcilb81ab1n18x5
Xi1[0] clkanystorev4034ml_rep clksrstore4034ml_rep[0] strotclkenm402l[0] fscan_clkungate_rep
+ vcc vss i0mcilb81ab1n18x5
Xi1[1] clkanystorev4034ml_rep clksrstore4034ml_rep[1] strotclkenm402l[1] fscan_clkungate_rep
+ vcc vss i0mcilb81ab1n18x5
Xi1[2] clkanystorev4034ml_rep clksrstore4034ml_rep[2] strotclkenm402l[2] fscan_clkungate_rep
+ vcc vss i0mcilb81ab1n18x5
Xgnac0 qb_nocon_gnac0__dpd1 vcc vss i0mydp122ub1n00x5
Xgnac1 qb_nocon_gnac1__dpd1 vcc vss i0mydp122ub1n00x5
Xgnac2 strotclkenm402l[0] vcc vss i0mydp122ub1n00x5
Xgnac3 qb_nocon_gnac3__dpd1 vcc vss i0mydp122ub1n00x5
Xgnac5 strotclkenm402l[1] vcc vss i0mydp122ub1n00x5
Xgnac6 strotclkenm402l[3] vcc vss i0mydp122ub1n00x5
Xgnac7 strotclkenm402l[2] vcc vss i0mydp122ub1n00x5
.ENDS

.SUBCKT dcu_store_rot_byte dcu_store_rot_ctrl_clkanystorev4034ml_rep dcu_store_rot_ctrl_fscan_clkungate_rep
+ stchunkrotctrlm403h_0_[1] stchunkrotctrlm403h_0_[0] stchunkrotctrlm403h_1_[1]
+ stchunkrotctrlm403h_1_[0] stchunkrotctrlm403h_2_[1] stchunkrotctrlm403h_2_[0]
+ stchunkrotctrlm403h_3_[1] stchunkrotctrlm403h_3_[0] strotalgnbdatchunkm403h[0][7]
+ strotalgnbdatchunkm403h[0][6] strotalgnbdatchunkm403h[0][5] strotalgnbdatchunkm403h[0][4]
+ strotalgnbdatchunkm403h[0][3] strotalgnbdatchunkm403h[0][2] strotalgnbdatchunkm403h[0][1]
+ strotalgnbdatchunkm403h[0][0] strotalgnbdatchunkm403h[1][7] strotalgnbdatchunkm403h[1][6]
+ strotalgnbdatchunkm403h[1][5] strotalgnbdatchunkm403h[1][4] strotalgnbdatchunkm403h[1][3]
+ strotalgnbdatchunkm403h[1][2] strotalgnbdatchunkm403h[1][1] strotalgnbdatchunkm403h[1][0]
+ strotalgnbdatchunkm403h[2][7] strotalgnbdatchunkm403h[2][6] strotalgnbdatchunkm403h[2][5]
+ strotalgnbdatchunkm403h[2][4] strotalgnbdatchunkm403h[2][3] strotalgnbdatchunkm403h[2][2]
+ strotalgnbdatchunkm403h[2][1] strotalgnbdatchunkm403h[2][0] strotalgnbdatchunkm403h[3][7]
+ strotalgnbdatchunkm403h[3][6] strotalgnbdatchunkm403h[3][5] strotalgnbdatchunkm403h[3][4]
+ strotalgnbdatchunkm403h[3][3] strotalgnbdatchunkm403h[3][2] strotalgnbdatchunkm403h[3][1]
+ strotalgnbdatchunkm403h[3][0] strotalgnbdatm403l_0_[7] strotalgnbdatm403l_0_[6]
+ strotalgnbdatm403l_0_[5] strotalgnbdatm403l_0_[4] strotalgnbdatm403l_0_[3] strotalgnbdatm403l_0_[2]
+ strotalgnbdatm403l_0_[1] strotalgnbdatm403l_0_[0] strotalgnbdatm403l_1_[7] strotalgnbdatm403l_1_[6]
+ strotalgnbdatm403l_1_[5] strotalgnbdatm403l_1_[4] strotalgnbdatm403l_1_[3] strotalgnbdatm403l_1_[2]
+ strotalgnbdatm403l_1_[1] strotalgnbdatm403l_1_[0] strotalgnbdatm403l_2_[7] strotalgnbdatm403l_2_[6]
+ strotalgnbdatm403l_2_[5] strotalgnbdatm403l_2_[4] strotalgnbdatm403l_2_[3] strotalgnbdatm403l_2_[2]
+ strotalgnbdatm403l_2_[1] strotalgnbdatm403l_2_[0] strotalgnbdatm403l_3_[7] strotalgnbdatm403l_3_[6]
+ strotalgnbdatm403l_3_[5] strotalgnbdatm403l_3_[4] strotalgnbdatm403l_3_[3] strotalgnbdatm403l_3_[2]
+ strotalgnbdatm403l_3_[1] strotalgnbdatm403l_3_[0] strotclkenm402l[3] strotclkenm402l[2]
+ strotclkenm402l[1] strotclkenm402l[0] vcc vss
Xidcu_store_rot_ctrl dcu_store_rot_ctrl_clkanystorev4034ml_rep clksrstore4034ml_rep[3]
+ clksrstore4034ml_rep[2] clksrstore4034ml_rep[1] clksrstore4034ml_rep[0] dcu_store_rot_ctrl_fscan_clkungate_rep
+ stchunkrotctrlm403h_0_[1] stchunkrotctrlm403h_0_[0] stchunkrotctrlm403h_1_[1]
+ stchunkrotctrlm403h_1_[0] stchunkrotctrlm403h_2_[1] stchunkrotctrlm403h_2_[0]
+ stchunkrotctrlm403h_3_[1] stchunkrotctrlm403h_3_[0] stchunkrotctrlm403h_sel[15]
+ stchunkrotctrlm403h_sel[14] stchunkrotctrlm403h_sel[13] stchunkrotctrlm403h_sel[12]
+ stchunkrotctrlm403h_sel[11] stchunkrotctrlm403h_sel[10] stchunkrotctrlm403h_sel[9]
+ stchunkrotctrlm403h_sel[8] stchunkrotctrlm403h_sel[7] stchunkrotctrlm403h_sel[6]
+ stchunkrotctrlm403h_sel[5] stchunkrotctrlm403h_sel[4] stchunkrotctrlm403h_sel[3]
+ stchunkrotctrlm403h_sel[2] stchunkrotctrlm403h_sel[1] stchunkrotctrlm403h_sel[0]
+ strotclkenm402l[3] strotclkenm402l[2] strotclkenm402l[1] strotclkenm402l[0] vcc
+ vss dcu_store_rot_ctrl
Xdcu_store_rot_4bit[3] stchunkrotctrlm403h_sel[3] stchunkrotctrlm403h_sel[2] stchunkrotctrlm403h_sel[1]
+ stchunkrotctrlm403h_sel[0] stchunkrotctrlm403h_sel[7] stchunkrotctrlm403h_sel[6]
+ stchunkrotctrlm403h_sel[5] stchunkrotctrlm403h_sel[4] stchunkrotctrlm403h_sel[11]
+ stchunkrotctrlm403h_sel[10] stchunkrotctrlm403h_sel[9] stchunkrotctrlm403h_sel[8]
+ stchunkrotctrlm403h_sel[15] stchunkrotctrlm403h_sel[14] stchunkrotctrlm403h_sel[13]
+ stchunkrotctrlm403h_sel[12] clksrstore4034ml_rep[3] clksrstore4034ml_rep[2] clksrstore4034ml_rep[1]
+ clksrstore4034ml_rep[0] strotalgnbdatm403l_0_[7] strotalgnbdatm403l_0_[6] strotalgnbdatm403l_1_[7]
+ strotalgnbdatm403l_1_[6] strotalgnbdatm403l_2_[7] strotalgnbdatm403l_2_[6] strotalgnbdatm403l_3_[7]
+ strotalgnbdatm403l_3_[6] strotalgnbdatchunkm403h[0][7] strotalgnbdatchunkm403h[0][6]
+ strotalgnbdatchunkm403h[1][7] strotalgnbdatchunkm403h[1][6] strotalgnbdatchunkm403h[2][7]
+ strotalgnbdatchunkm403h[2][6] strotalgnbdatchunkm403h[3][7] strotalgnbdatchunkm403h[3][6]
+ vcc vss dcu_store_rot_4bit
Xdcu_store_rot_4bit[0] stchunkrotctrlm403h_sel[3] stchunkrotctrlm403h_sel[2] stchunkrotctrlm403h_sel[1]
+ stchunkrotctrlm403h_sel[0] stchunkrotctrlm403h_sel[7] stchunkrotctrlm403h_sel[6]
+ stchunkrotctrlm403h_sel[5] stchunkrotctrlm403h_sel[4] stchunkrotctrlm403h_sel[11]
+ stchunkrotctrlm403h_sel[10] stchunkrotctrlm403h_sel[9] stchunkrotctrlm403h_sel[8]
+ stchunkrotctrlm403h_sel[15] stchunkrotctrlm403h_sel[14] stchunkrotctrlm403h_sel[13]
+ stchunkrotctrlm403h_sel[12] clksrstore4034ml_rep[3] clksrstore4034ml_rep[2] clksrstore4034ml_rep[1]
+ clksrstore4034ml_rep[0] strotalgnbdatm403l_0_[1] strotalgnbdatm403l_0_[0] strotalgnbdatm403l_1_[1]
+ strotalgnbdatm403l_1_[0] strotalgnbdatm403l_2_[1] strotalgnbdatm403l_2_[0] strotalgnbdatm403l_3_[1]
+ strotalgnbdatm403l_3_[0] strotalgnbdatchunkm403h[0][1] strotalgnbdatchunkm403h[0][0]
+ strotalgnbdatchunkm403h[1][1] strotalgnbdatchunkm403h[1][0] strotalgnbdatchunkm403h[2][1]
+ strotalgnbdatchunkm403h[2][0] strotalgnbdatchunkm403h[3][1] strotalgnbdatchunkm403h[3][0]
+ vcc vss dcu_store_rot_4bit
Xdcu_store_rot_4bit[2] stchunkrotctrlm403h_sel[3] stchunkrotctrlm403h_sel[2] stchunkrotctrlm403h_sel[1]
+ stchunkrotctrlm403h_sel[0] stchunkrotctrlm403h_sel[7] stchunkrotctrlm403h_sel[6]
+ stchunkrotctrlm403h_sel[5] stchunkrotctrlm403h_sel[4] stchunkrotctrlm403h_sel[11]
+ stchunkrotctrlm403h_sel[10] stchunkrotctrlm403h_sel[9] stchunkrotctrlm403h_sel[8]
+ stchunkrotctrlm403h_sel[15] stchunkrotctrlm403h_sel[14] stchunkrotctrlm403h_sel[13]
+ stchunkrotctrlm403h_sel[12] clksrstore4034ml_rep[3] clksrstore4034ml_rep[2] clksrstore4034ml_rep[1]
+ clksrstore4034ml_rep[0] strotalgnbdatm403l_0_[5] strotalgnbdatm403l_0_[4] strotalgnbdatm403l_1_[5]
+ strotalgnbdatm403l_1_[4] strotalgnbdatm403l_2_[5] strotalgnbdatm403l_2_[4] strotalgnbdatm403l_3_[5]
+ strotalgnbdatm403l_3_[4] strotalgnbdatchunkm403h[0][5] strotalgnbdatchunkm403h[0][4]
+ strotalgnbdatchunkm403h[1][5] strotalgnbdatchunkm403h[1][4] strotalgnbdatchunkm403h[2][5]
+ strotalgnbdatchunkm403h[2][4] strotalgnbdatchunkm403h[3][5] strotalgnbdatchunkm403h[3][4]
+ vcc vss dcu_store_rot_4bit
Xdcu_store_rot_4bit[1] stchunkrotctrlm403h_sel[3] stchunkrotctrlm403h_sel[2] stchunkrotctrlm403h_sel[1]
+ stchunkrotctrlm403h_sel[0] stchunkrotctrlm403h_sel[7] stchunkrotctrlm403h_sel[6]
+ stchunkrotctrlm403h_sel[5] stchunkrotctrlm403h_sel[4] stchunkrotctrlm403h_sel[11]
+ stchunkrotctrlm403h_sel[10] stchunkrotctrlm403h_sel[9] stchunkrotctrlm403h_sel[8]
+ stchunkrotctrlm403h_sel[15] stchunkrotctrlm403h_sel[14] stchunkrotctrlm403h_sel[13]
+ stchunkrotctrlm403h_sel[12] clksrstore4034ml_rep[3] clksrstore4034ml_rep[2] clksrstore4034ml_rep[1]
+ clksrstore4034ml_rep[0] strotalgnbdatm403l_0_[3] strotalgnbdatm403l_0_[2] strotalgnbdatm403l_1_[3]
+ strotalgnbdatm403l_1_[2] strotalgnbdatm403l_2_[3] strotalgnbdatm403l_2_[2] strotalgnbdatm403l_3_[3]
+ strotalgnbdatm403l_3_[2] strotalgnbdatchunkm403h[0][3] strotalgnbdatchunkm403h[0][2]
+ strotalgnbdatchunkm403h[1][3] strotalgnbdatchunkm403h[1][2] strotalgnbdatchunkm403h[2][3]
+ strotalgnbdatchunkm403h[2][2] strotalgnbdatchunkm403h[3][3] strotalgnbdatchunkm403h[3][2]
+ vcc vss dcu_store_rot_4bit
.ENDS

.SUBCKT dcu_rotd_byte chunkrotctrlm403l_0_[1] chunkrotctrlm403l_0_[0] chunkrotctrlm403l_1_[1]
+ chunkrotctrlm403l_1_[0] chunkrotoutintnobcstm403l_0_[7] chunkrotoutintnobcstm403l_0_[6]
+ chunkrotoutintnobcstm403l_0_[5] chunkrotoutintnobcstm403l_0_[4] chunkrotoutintnobcstm403l_0_[3]
+ chunkrotoutintnobcstm403l_0_[2] chunkrotoutintnobcstm403l_0_[1] chunkrotoutintnobcstm403l_0_[0]
+ chunkrotoutintnobcstm403l_1_[7] chunkrotoutintnobcstm403l_1_[6] chunkrotoutintnobcstm403l_1_[5]
+ chunkrotoutintnobcstm403l_1_[4] chunkrotoutintnobcstm403l_1_[3] chunkrotoutintnobcstm403l_1_[2]
+ chunkrotoutintnobcstm403l_1_[1] chunkrotoutintnobcstm403l_1_[0] chunkrotoutvecnobcstm403l_0_[7]
+ chunkrotoutvecnobcstm403l_0_[6] chunkrotoutvecnobcstm403l_0_[5] chunkrotoutvecnobcstm403l_0_[4]
+ chunkrotoutvecnobcstm403l_0_[3] chunkrotoutvecnobcstm403l_0_[2] chunkrotoutvecnobcstm403l_0_[1]
+ chunkrotoutvecnobcstm403l_0_[0] chunkrotoutvecnobcstm403l_1_[7] chunkrotoutvecnobcstm403l_1_[6]
+ chunkrotoutvecnobcstm403l_1_[5] chunkrotoutvecnobcstm403l_1_[4] chunkrotoutvecnobcstm403l_1_[3]
+ chunkrotoutvecnobcstm403l_1_[2] chunkrotoutvecnobcstm403l_1_[1] chunkrotoutvecnobcstm403l_1_[0]
+ rotrdportbrotbm403l[3] rotrdportbrotbm403l[2] rotrdportbrotbm403l[1] rotrdportbrotbm403l[0]
+ unaligndatl1am403l[0][7] unaligndatl1am403l[0][6] unaligndatl1am403l[0][5] unaligndatl1am403l[0][4]
+ unaligndatl1am403l[0][3] unaligndatl1am403l[0][2] unaligndatl1am403l[0][1] unaligndatl1am403l[0][0]
+ unaligndatl1am403l[1][7] unaligndatl1am403l[1][6] unaligndatl1am403l[1][5] unaligndatl1am403l[1][4]
+ unaligndatl1am403l[1][3] unaligndatl1am403l[1][2] unaligndatl1am403l[1][1] unaligndatl1am403l[1][0]
+ unaligndatl1am403l[2][7] unaligndatl1am403l[2][6] unaligndatl1am403l[2][5] unaligndatl1am403l[2][4]
+ unaligndatl1am403l[2][3] unaligndatl1am403l[2][2] unaligndatl1am403l[2][1] unaligndatl1am403l[2][0]
+ unaligndatl1am403l[3][7] unaligndatl1am403l[3][6] unaligndatl1am403l[3][5] unaligndatl1am403l[3][4]
+ unaligndatl1am403l[3][3] unaligndatl1am403l[3][2] unaligndatl1am403l[3][1] unaligndatl1am403l[3][0]
+ unaligndatl1bm403l[0][7] unaligndatl1bm403l[0][6] unaligndatl1bm403l[0][5] unaligndatl1bm403l[0][4]
+ unaligndatl1bm403l[0][3] unaligndatl1bm403l[0][2] unaligndatl1bm403l[0][1] unaligndatl1bm403l[0][0]
+ unaligndatl1bm403l[1][7] unaligndatl1bm403l[1][6] unaligndatl1bm403l[1][5] unaligndatl1bm403l[1][4]
+ unaligndatl1bm403l[1][3] unaligndatl1bm403l[1][2] unaligndatl1bm403l[1][1] unaligndatl1bm403l[1][0]
+ unaligndatl1bm403l[2][7] unaligndatl1bm403l[2][6] unaligndatl1bm403l[2][5] unaligndatl1bm403l[2][4]
+ unaligndatl1bm403l[2][3] unaligndatl1bm403l[2][2] unaligndatl1bm403l[2][1] unaligndatl1bm403l[2][0]
+ unaligndatl1bm403l[3][7] unaligndatl1bm403l[3][6] unaligndatl1bm403l[3][5] unaligndatl1bm403l[3][4]
+ unaligndatl1bm403l[3][3] unaligndatl1bm403l[3][2] unaligndatl1bm403l[3][1] unaligndatl1bm403l[3][0]
+ vcc vss
Xidcu_rotd_2bit[2] chunkrotctrlm403l_sel0[3] chunkrotctrlm403l_sel0[2] chunkrotctrlm403l_sel0[1]
+ chunkrotctrlm403l_sel0[0] chunkrotctrlm403l_sel1[2] chunkrotctrlm403l_sel1[1]
+ chunkrotctrlm403l_sel1[0] chunkrotctrlm403l_sel1[3] chunkrotoutintnobcstm403l_0_[5]
+ chunkrotoutintnobcstm403l_0_[4] chunkrotoutintnobcstm403l_1_[5] chunkrotoutintnobcstm403l_1_[4]
+ chunkrotoutvecnobcstm403l_0_[5] chunkrotoutvecnobcstm403l_0_[4] chunkrotoutvecnobcstm403l_1_[5]
+ chunkrotoutvecnobcstm403l_1_[4] rotrdportbrotbm403l_rep[3] rotrdportbrotbm403l_rep[2]
+ rotrdportbrotbm403l_rep[1] rotrdportbrotbm403l_rep[0] unaligndatl1am403l[0][5]
+ unaligndatl1am403l[0][4] unaligndatl1am403l[1][5] unaligndatl1am403l[1][4] unaligndatl1am403l[2][5]
+ unaligndatl1am403l[2][4] unaligndatl1am403l[3][5] unaligndatl1am403l[3][4] unaligndatl1bm403l[0][5]
+ unaligndatl1bm403l[0][4] unaligndatl1bm403l[1][5] unaligndatl1bm403l[1][4] unaligndatl1bm403l[2][5]
+ unaligndatl1bm403l[2][4] unaligndatl1bm403l[3][5] unaligndatl1bm403l[3][4] vcc
+ vss dcu_rotd_2bit
Xidcu_rotd_2bit[3] chunkrotctrlm403l_sel0[3] chunkrotctrlm403l_sel0[2] chunkrotctrlm403l_sel0[1]
+ chunkrotctrlm403l_sel0[0] chunkrotctrlm403l_sel1[2] chunkrotctrlm403l_sel1[1]
+ chunkrotctrlm403l_sel1[0] chunkrotctrlm403l_sel1[3] chunkrotoutintnobcstm403l_0_[7]
+ chunkrotoutintnobcstm403l_0_[6] chunkrotoutintnobcstm403l_1_[7] chunkrotoutintnobcstm403l_1_[6]
+ chunkrotoutvecnobcstm403l_0_[7] chunkrotoutvecnobcstm403l_0_[6] chunkrotoutvecnobcstm403l_1_[7]
+ chunkrotoutvecnobcstm403l_1_[6] rotrdportbrotbm403l_rep[3] rotrdportbrotbm403l_rep[2]
+ rotrdportbrotbm403l_rep[1] rotrdportbrotbm403l_rep[0] unaligndatl1am403l[0][7]
+ unaligndatl1am403l[0][6] unaligndatl1am403l[1][7] unaligndatl1am403l[1][6] unaligndatl1am403l[2][7]
+ unaligndatl1am403l[2][6] unaligndatl1am403l[3][7] unaligndatl1am403l[3][6] unaligndatl1bm403l[0][7]
+ unaligndatl1bm403l[0][6] unaligndatl1bm403l[1][7] unaligndatl1bm403l[1][6] unaligndatl1bm403l[2][7]
+ unaligndatl1bm403l[2][6] unaligndatl1bm403l[3][7] unaligndatl1bm403l[3][6] vcc
+ vss dcu_rotd_2bit
Xidcu_rotd_2bit[0] chunkrotctrlm403l_sel0[3] chunkrotctrlm403l_sel0[2] chunkrotctrlm403l_sel0[1]
+ chunkrotctrlm403l_sel0[0] chunkrotctrlm403l_sel1[2] chunkrotctrlm403l_sel1[1]
+ chunkrotctrlm403l_sel1[0] chunkrotctrlm403l_sel1[3] chunkrotoutintnobcstm403l_0_[1]
+ chunkrotoutintnobcstm403l_0_[0] chunkrotoutintnobcstm403l_1_[1] chunkrotoutintnobcstm403l_1_[0]
+ chunkrotoutvecnobcstm403l_0_[1] chunkrotoutvecnobcstm403l_0_[0] chunkrotoutvecnobcstm403l_1_[1]
+ chunkrotoutvecnobcstm403l_1_[0] rotrdportbrotbm403l_rep[3] rotrdportbrotbm403l_rep[2]
+ rotrdportbrotbm403l_rep[1] rotrdportbrotbm403l_rep[0] unaligndatl1am403l[0][1]
+ unaligndatl1am403l[0][0] unaligndatl1am403l[1][1] unaligndatl1am403l[1][0] unaligndatl1am403l[2][1]
+ unaligndatl1am403l[2][0] unaligndatl1am403l[3][1] unaligndatl1am403l[3][0] unaligndatl1bm403l[0][1]
+ unaligndatl1bm403l[0][0] unaligndatl1bm403l[1][1] unaligndatl1bm403l[1][0] unaligndatl1bm403l[2][1]
+ unaligndatl1bm403l[2][0] unaligndatl1bm403l[3][1] unaligndatl1bm403l[3][0] vcc
+ vss dcu_rotd_2bit
Xidcu_rotd_2bit[1] chunkrotctrlm403l_sel0[3] chunkrotctrlm403l_sel0[2] chunkrotctrlm403l_sel0[1]
+ chunkrotctrlm403l_sel0[0] chunkrotctrlm403l_sel1[2] chunkrotctrlm403l_sel1[1]
+ chunkrotctrlm403l_sel1[0] chunkrotctrlm403l_sel1[3] chunkrotoutintnobcstm403l_0_[3]
+ chunkrotoutintnobcstm403l_0_[2] chunkrotoutintnobcstm403l_1_[3] chunkrotoutintnobcstm403l_1_[2]
+ chunkrotoutvecnobcstm403l_0_[3] chunkrotoutvecnobcstm403l_0_[2] chunkrotoutvecnobcstm403l_1_[3]
+ chunkrotoutvecnobcstm403l_1_[2] rotrdportbrotbm403l_rep[3] rotrdportbrotbm403l_rep[2]
+ rotrdportbrotbm403l_rep[1] rotrdportbrotbm403l_rep[0] unaligndatl1am403l[0][3]
+ unaligndatl1am403l[0][2] unaligndatl1am403l[1][3] unaligndatl1am403l[1][2] unaligndatl1am403l[2][3]
+ unaligndatl1am403l[2][2] unaligndatl1am403l[3][3] unaligndatl1am403l[3][2] unaligndatl1bm403l[0][3]
+ unaligndatl1bm403l[0][2] unaligndatl1bm403l[1][3] unaligndatl1bm403l[1][2] unaligndatl1bm403l[2][3]
+ unaligndatl1bm403l[2][2] unaligndatl1bm403l[3][3] unaligndatl1bm403l[3][2] vcc
+ vss dcu_rotd_2bit
Xidcu_rotd_ctrl chunkrotctrlm403l_0_[1] chunkrotctrlm403l_0_[0] chunkrotctrlm403l_1_[1]
+ chunkrotctrlm403l_1_[0] chunkrotctrlm403l_sel0[3] chunkrotctrlm403l_sel0[2] chunkrotctrlm403l_sel0[1]
+ chunkrotctrlm403l_sel0[0] chunkrotctrlm403l_sel1[3] chunkrotctrlm403l_sel1[2]
+ chunkrotctrlm403l_sel1[1] chunkrotctrlm403l_sel1[0] rotrdportbrotbm403l[3] rotrdportbrotbm403l[2]
+ rotrdportbrotbm403l[1] rotrdportbrotbm403l[0] rotrdportbrotbm403l_rep[3] rotrdportbrotbm403l_rep[2]
+ rotrdportbrotbm403l_rep[1] rotrdportbrotbm403l_rep[0] vcc vss dcu_rotd_ctrl
.ENDS

.SUBCKT dcchunk_rot chunkrotctrlm403l_0_0_[1] chunkrotctrlm403l_0_0_[0] chunkrotctrlm403l_0_1_[1]
+ chunkrotctrlm403l_0_1_[0] chunkrotctrlm403l_1_0_[1] chunkrotctrlm403l_1_0_[0]
+ chunkrotctrlm403l_1_1_[1] chunkrotctrlm403l_1_1_[0] chunkrotctrlm403l_2_0_[1]
+ chunkrotctrlm403l_2_0_[0] chunkrotctrlm403l_2_1_[1] chunkrotctrlm403l_2_1_[0]
+ chunkrotctrlm403l_3_0_[1] chunkrotctrlm403l_3_0_[0] chunkrotctrlm403l_3_1_[1]
+ chunkrotctrlm403l_3_1_[0] chunkrotoutintnobcstm403l_0__0__data[7] chunkrotoutintnobcstm403l_0__0__data[6]
+ chunkrotoutintnobcstm403l_0__0__data[5] chunkrotoutintnobcstm403l_0__0__data[4]
+ chunkrotoutintnobcstm403l_0__0__data[3] chunkrotoutintnobcstm403l_0__0__data[2]
+ chunkrotoutintnobcstm403l_0__0__data[1] chunkrotoutintnobcstm403l_0__0__data[0]
+ chunkrotoutintnobcstm403l_0__1__data[7] chunkrotoutintnobcstm403l_0__1__data[6]
+ chunkrotoutintnobcstm403l_0__1__data[5] chunkrotoutintnobcstm403l_0__1__data[4]
+ chunkrotoutintnobcstm403l_0__1__data[3] chunkrotoutintnobcstm403l_0__1__data[2]
+ chunkrotoutintnobcstm403l_0__1__data[1] chunkrotoutintnobcstm403l_0__1__data[0]
+ chunkrotoutintnobcstm403l_1__0__data[7] chunkrotoutintnobcstm403l_1__0__data[6]
+ chunkrotoutintnobcstm403l_1__0__data[5] chunkrotoutintnobcstm403l_1__0__data[4]
+ chunkrotoutintnobcstm403l_1__0__data[3] chunkrotoutintnobcstm403l_1__0__data[2]
+ chunkrotoutintnobcstm403l_1__0__data[1] chunkrotoutintnobcstm403l_1__0__data[0]
+ chunkrotoutintnobcstm403l_1__1__data[7] chunkrotoutintnobcstm403l_1__1__data[6]
+ chunkrotoutintnobcstm403l_1__1__data[5] chunkrotoutintnobcstm403l_1__1__data[4]
+ chunkrotoutintnobcstm403l_1__1__data[3] chunkrotoutintnobcstm403l_1__1__data[2]
+ chunkrotoutintnobcstm403l_1__1__data[1] chunkrotoutintnobcstm403l_1__1__data[0]
+ chunkrotoutintnobcstm403l_2__0__data[7] chunkrotoutintnobcstm403l_2__0__data[6]
+ chunkrotoutintnobcstm403l_2__0__data[5] chunkrotoutintnobcstm403l_2__0__data[4]
+ chunkrotoutintnobcstm403l_2__0__data[3] chunkrotoutintnobcstm403l_2__0__data[2]
+ chunkrotoutintnobcstm403l_2__0__data[1] chunkrotoutintnobcstm403l_2__0__data[0]
+ chunkrotoutintnobcstm403l_2__1__data[7] chunkrotoutintnobcstm403l_2__1__data[6]
+ chunkrotoutintnobcstm403l_2__1__data[5] chunkrotoutintnobcstm403l_2__1__data[4]
+ chunkrotoutintnobcstm403l_2__1__data[3] chunkrotoutintnobcstm403l_2__1__data[2]
+ chunkrotoutintnobcstm403l_2__1__data[1] chunkrotoutintnobcstm403l_2__1__data[0]
+ chunkrotoutintnobcstm403l_3__0__data[7] chunkrotoutintnobcstm403l_3__0__data[6]
+ chunkrotoutintnobcstm403l_3__0__data[5] chunkrotoutintnobcstm403l_3__0__data[4]
+ chunkrotoutintnobcstm403l_3__0__data[3] chunkrotoutintnobcstm403l_3__0__data[2]
+ chunkrotoutintnobcstm403l_3__0__data[1] chunkrotoutintnobcstm403l_3__0__data[0]
+ chunkrotoutintnobcstm403l_3__1__data[7] chunkrotoutintnobcstm403l_3__1__data[6]
+ chunkrotoutintnobcstm403l_3__1__data[5] chunkrotoutintnobcstm403l_3__1__data[4]
+ chunkrotoutintnobcstm403l_3__1__data[3] chunkrotoutintnobcstm403l_3__1__data[2]
+ chunkrotoutintnobcstm403l_3__1__data[1] chunkrotoutintnobcstm403l_3__1__data[0]
+ chunkrotoutvecnobcstm403l_0__0__data[7] chunkrotoutvecnobcstm403l_0__0__data[6]
+ chunkrotoutvecnobcstm403l_0__0__data[5] chunkrotoutvecnobcstm403l_0__0__data[4]
+ chunkrotoutvecnobcstm403l_0__0__data[3] chunkrotoutvecnobcstm403l_0__0__data[2]
+ chunkrotoutvecnobcstm403l_0__0__data[1] chunkrotoutvecnobcstm403l_0__0__data[0]
+ chunkrotoutvecnobcstm403l_0__1__data[7] chunkrotoutvecnobcstm403l_0__1__data[6]
+ chunkrotoutvecnobcstm403l_0__1__data[5] chunkrotoutvecnobcstm403l_0__1__data[4]
+ chunkrotoutvecnobcstm403l_0__1__data[3] chunkrotoutvecnobcstm403l_0__1__data[2]
+ chunkrotoutvecnobcstm403l_0__1__data[1] chunkrotoutvecnobcstm403l_0__1__data[0]
+ chunkrotoutvecnobcstm403l_1__0__data[7] chunkrotoutvecnobcstm403l_1__0__data[6]
+ chunkrotoutvecnobcstm403l_1__0__data[5] chunkrotoutvecnobcstm403l_1__0__data[4]
+ chunkrotoutvecnobcstm403l_1__0__data[3] chunkrotoutvecnobcstm403l_1__0__data[2]
+ chunkrotoutvecnobcstm403l_1__0__data[1] chunkrotoutvecnobcstm403l_1__0__data[0]
+ chunkrotoutvecnobcstm403l_1__1__data[7] chunkrotoutvecnobcstm403l_1__1__data[6]
+ chunkrotoutvecnobcstm403l_1__1__data[5] chunkrotoutvecnobcstm403l_1__1__data[4]
+ chunkrotoutvecnobcstm403l_1__1__data[3] chunkrotoutvecnobcstm403l_1__1__data[2]
+ chunkrotoutvecnobcstm403l_1__1__data[1] chunkrotoutvecnobcstm403l_1__1__data[0]
+ chunkrotoutvecnobcstm403l_2__0__data[7] chunkrotoutvecnobcstm403l_2__0__data[6]
+ chunkrotoutvecnobcstm403l_2__0__data[5] chunkrotoutvecnobcstm403l_2__0__data[4]
+ chunkrotoutvecnobcstm403l_2__0__data[3] chunkrotoutvecnobcstm403l_2__0__data[2]
+ chunkrotoutvecnobcstm403l_2__0__data[1] chunkrotoutvecnobcstm403l_2__0__data[0]
+ chunkrotoutvecnobcstm403l_2__1__data[7] chunkrotoutvecnobcstm403l_2__1__data[6]
+ chunkrotoutvecnobcstm403l_2__1__data[5] chunkrotoutvecnobcstm403l_2__1__data[4]
+ chunkrotoutvecnobcstm403l_2__1__data[3] chunkrotoutvecnobcstm403l_2__1__data[2]
+ chunkrotoutvecnobcstm403l_2__1__data[1] chunkrotoutvecnobcstm403l_2__1__data[0]
+ chunkrotoutvecnobcstm403l_3__0__data[7] chunkrotoutvecnobcstm403l_3__0__data[6]
+ chunkrotoutvecnobcstm403l_3__0__data[5] chunkrotoutvecnobcstm403l_3__0__data[4]
+ chunkrotoutvecnobcstm403l_3__0__data[3] chunkrotoutvecnobcstm403l_3__0__data[2]
+ chunkrotoutvecnobcstm403l_3__0__data[1] chunkrotoutvecnobcstm403l_3__0__data[0]
+ chunkrotoutvecnobcstm403l_3__1__data[7] chunkrotoutvecnobcstm403l_3__1__data[6]
+ chunkrotoutvecnobcstm403l_3__1__data[5] chunkrotoutvecnobcstm403l_3__1__data[4]
+ chunkrotoutvecnobcstm403l_3__1__data[3] chunkrotoutvecnobcstm403l_3__1__data[2]
+ chunkrotoutvecnobcstm403l_3__1__data[1] chunkrotoutvecnobcstm403l_3__1__data[0]
+ fscan_clkungate lcpctrl_fd[0] lcpctrl_rd[0] mclk rotrdportbrotbm403l[3] rotrdportbrotbm403l[2]
+ rotrdportbrotbm403l[1] rotrdportbrotbm403l[0] rotrdportbrotdm403l[3] rotrdportbrotdm403l[2]
+ rotrdportbrotdm403l[1] rotrdportbrotdm403l[0] signal_elevate_fscan_clkungate stchunkrotctrlm403h_0_[1]
+ stchunkrotctrlm403h_0_[0] stchunkrotctrlm403h_1_[1] stchunkrotctrlm403h_1_[0]
+ stchunkrotctrlm403h_2_[1] stchunkrotctrlm403h_2_[0] stchunkrotctrlm403h_3_[1]
+ stchunkrotctrlm403h_3_[0] strotalgnbdatchunkm403h[0][7] strotalgnbdatchunkm403h[0][6]
+ strotalgnbdatchunkm403h[0][5] strotalgnbdatchunkm403h[0][4] strotalgnbdatchunkm403h[0][3]
+ strotalgnbdatchunkm403h[0][2] strotalgnbdatchunkm403h[0][1] strotalgnbdatchunkm403h[0][0]
+ strotalgnbdatchunkm403h[1][7] strotalgnbdatchunkm403h[1][6] strotalgnbdatchunkm403h[1][5]
+ strotalgnbdatchunkm403h[1][4] strotalgnbdatchunkm403h[1][3] strotalgnbdatchunkm403h[1][2]
+ strotalgnbdatchunkm403h[1][1] strotalgnbdatchunkm403h[1][0] strotalgnbdatchunkm403h[2][7]
+ strotalgnbdatchunkm403h[2][6] strotalgnbdatchunkm403h[2][5] strotalgnbdatchunkm403h[2][4]
+ strotalgnbdatchunkm403h[2][3] strotalgnbdatchunkm403h[2][2] strotalgnbdatchunkm403h[2][1]
+ strotalgnbdatchunkm403h[2][0] strotalgnbdatchunkm403h[3][7] strotalgnbdatchunkm403h[3][6]
+ strotalgnbdatchunkm403h[3][5] strotalgnbdatchunkm403h[3][4] strotalgnbdatchunkm403h[3][3]
+ strotalgnbdatchunkm403h[3][2] strotalgnbdatchunkm403h[3][1] strotalgnbdatchunkm403h[3][0]
+ strotalgnbdatm403l_0_[7] strotalgnbdatm403l_0_[6] strotalgnbdatm403l_0_[5] strotalgnbdatm403l_0_[4]
+ strotalgnbdatm403l_0_[3] strotalgnbdatm403l_0_[2] strotalgnbdatm403l_0_[1] strotalgnbdatm403l_0_[0]
+ strotalgnbdatm403l_1_[7] strotalgnbdatm403l_1_[6] strotalgnbdatm403l_1_[5] strotalgnbdatm403l_1_[4]
+ strotalgnbdatm403l_1_[3] strotalgnbdatm403l_1_[2] strotalgnbdatm403l_1_[1] strotalgnbdatm403l_1_[0]
+ strotalgnbdatm403l_2_[7] strotalgnbdatm403l_2_[6] strotalgnbdatm403l_2_[5] strotalgnbdatm403l_2_[4]
+ strotalgnbdatm403l_2_[3] strotalgnbdatm403l_2_[2] strotalgnbdatm403l_2_[1] strotalgnbdatm403l_2_[0]
+ strotalgnbdatm403l_3_[7] strotalgnbdatm403l_3_[6] strotalgnbdatm403l_3_[5] strotalgnbdatm403l_3_[4]
+ strotalgnbdatm403l_3_[3] strotalgnbdatm403l_3_[2] strotalgnbdatm403l_3_[1] strotalgnbdatm403l_3_[0]
+ strotclkenm402l[3] strotclkenm402l[2] strotclkenm402l[1] strotclkenm402l[0] unaligndatl1am403l[0][7]
+ unaligndatl1am403l[0][6] unaligndatl1am403l[0][5] unaligndatl1am403l[0][4] unaligndatl1am403l[0][3]
+ unaligndatl1am403l[0][2] unaligndatl1am403l[0][1] unaligndatl1am403l[0][0] unaligndatl1am403l[1][7]
+ unaligndatl1am403l[1][6] unaligndatl1am403l[1][5] unaligndatl1am403l[1][4] unaligndatl1am403l[1][3]
+ unaligndatl1am403l[1][2] unaligndatl1am403l[1][1] unaligndatl1am403l[1][0] unaligndatl1am403l[2][7]
+ unaligndatl1am403l[2][6] unaligndatl1am403l[2][5] unaligndatl1am403l[2][4] unaligndatl1am403l[2][3]
+ unaligndatl1am403l[2][2] unaligndatl1am403l[2][1] unaligndatl1am403l[2][0] unaligndatl1am403l[3][7]
+ unaligndatl1am403l[3][6] unaligndatl1am403l[3][5] unaligndatl1am403l[3][4] unaligndatl1am403l[3][3]
+ unaligndatl1am403l[3][2] unaligndatl1am403l[3][1] unaligndatl1am403l[3][0] unaligndatl1bm403l[0][7]
+ unaligndatl1bm403l[0][6] unaligndatl1bm403l[0][5] unaligndatl1bm403l[0][4] unaligndatl1bm403l[0][3]
+ unaligndatl1bm403l[0][2] unaligndatl1bm403l[0][1] unaligndatl1bm403l[0][0] unaligndatl1bm403l[1][7]
+ unaligndatl1bm403l[1][6] unaligndatl1bm403l[1][5] unaligndatl1bm403l[1][4] unaligndatl1bm403l[1][3]
+ unaligndatl1bm403l[1][2] unaligndatl1bm403l[1][1] unaligndatl1bm403l[1][0] unaligndatl1bm403l[2][7]
+ unaligndatl1bm403l[2][6] unaligndatl1bm403l[2][5] unaligndatl1bm403l[2][4] unaligndatl1bm403l[2][3]
+ unaligndatl1bm403l[2][2] unaligndatl1bm403l[2][1] unaligndatl1bm403l[2][0] unaligndatl1bm403l[3][7]
+ unaligndatl1bm403l[3][6] unaligndatl1bm403l[3][5] unaligndatl1bm403l[3][4] unaligndatl1bm403l[3][3]
+ unaligndatl1bm403l[3][2] unaligndatl1bm403l[3][1] unaligndatl1bm403l[3][0] vcc
+ vss
Xirep fscan_clkungate fscan_clkungate_rep vcc vss i0mbfn000ab1n09x5
Xi6[1] mclk clkanystorev4034ml_rep lcpctrl_fd[0] lcpctrl_rd[0] vcc vss i0mcrb0bfab1n18x5
Xidcu_rotb_byte chunkrotctrlm403l_1_0_[1] chunkrotctrlm403l_1_0_[0] chunkrotctrlm403l_1_1_[1]
+ chunkrotctrlm403l_1_1_[0] chunkrotoutintnobcstm403l_1__0__data[7] chunkrotoutintnobcstm403l_1__0__data[6]
+ chunkrotoutintnobcstm403l_1__0__data[5] chunkrotoutintnobcstm403l_1__0__data[4]
+ chunkrotoutintnobcstm403l_1__0__data[3] chunkrotoutintnobcstm403l_1__0__data[2]
+ chunkrotoutintnobcstm403l_1__0__data[1] chunkrotoutintnobcstm403l_1__0__data[0]
+ chunkrotoutintnobcstm403l_1__1__data[7] chunkrotoutintnobcstm403l_1__1__data[6]
+ chunkrotoutintnobcstm403l_1__1__data[5] chunkrotoutintnobcstm403l_1__1__data[4]
+ chunkrotoutintnobcstm403l_1__1__data[3] chunkrotoutintnobcstm403l_1__1__data[2]
+ chunkrotoutintnobcstm403l_1__1__data[1] chunkrotoutintnobcstm403l_1__1__data[0]
+ chunkrotoutvecnobcstm403l_1__0__data[7] chunkrotoutvecnobcstm403l_1__0__data[6]
+ chunkrotoutvecnobcstm403l_1__0__data[5] chunkrotoutvecnobcstm403l_1__0__data[4]
+ chunkrotoutvecnobcstm403l_1__0__data[3] chunkrotoutvecnobcstm403l_1__0__data[2]
+ chunkrotoutvecnobcstm403l_1__0__data[1] chunkrotoutvecnobcstm403l_1__0__data[0]
+ chunkrotoutvecnobcstm403l_1__1__data[7] chunkrotoutvecnobcstm403l_1__1__data[6]
+ chunkrotoutvecnobcstm403l_1__1__data[5] chunkrotoutvecnobcstm403l_1__1__data[4]
+ chunkrotoutvecnobcstm403l_1__1__data[3] chunkrotoutvecnobcstm403l_1__1__data[2]
+ chunkrotoutvecnobcstm403l_1__1__data[1] chunkrotoutvecnobcstm403l_1__1__data[0]
+ rotrdportbrotbm403l[3] rotrdportbrotbm403l[2] rotrdportbrotbm403l[1] rotrdportbrotbm403l[0]
+ unaligndatl1am403l[0][7] unaligndatl1am403l[0][6] unaligndatl1am403l[0][5] unaligndatl1am403l[0][4]
+ unaligndatl1am403l[0][3] unaligndatl1am403l[0][2] unaligndatl1am403l[0][1] unaligndatl1am403l[0][0]
+ unaligndatl1am403l[1][7] unaligndatl1am403l[1][6] unaligndatl1am403l[1][5] unaligndatl1am403l[1][4]
+ unaligndatl1am403l[1][3] unaligndatl1am403l[1][2] unaligndatl1am403l[1][1] unaligndatl1am403l[1][0]
+ unaligndatl1am403l[2][7] unaligndatl1am403l[2][6] unaligndatl1am403l[2][5] unaligndatl1am403l[2][4]
+ unaligndatl1am403l[2][3] unaligndatl1am403l[2][2] unaligndatl1am403l[2][1] unaligndatl1am403l[2][0]
+ unaligndatl1am403l[3][7] unaligndatl1am403l[3][6] unaligndatl1am403l[3][5] unaligndatl1am403l[3][4]
+ unaligndatl1am403l[3][3] unaligndatl1am403l[3][2] unaligndatl1am403l[3][1] unaligndatl1am403l[3][0]
+ unaligndatl1bm403l[0][7] unaligndatl1bm403l[0][6] unaligndatl1bm403l[0][5] unaligndatl1bm403l[0][4]
+ unaligndatl1bm403l[0][3] unaligndatl1bm403l[0][2] unaligndatl1bm403l[0][1] unaligndatl1bm403l[0][0]
+ unaligndatl1bm403l[1][7] unaligndatl1bm403l[1][6] unaligndatl1bm403l[1][5] unaligndatl1bm403l[1][4]
+ unaligndatl1bm403l[1][3] unaligndatl1bm403l[1][2] unaligndatl1bm403l[1][1] unaligndatl1bm403l[1][0]
+ unaligndatl1bm403l[2][7] unaligndatl1bm403l[2][6] unaligndatl1bm403l[2][5] unaligndatl1bm403l[2][4]
+ unaligndatl1bm403l[2][3] unaligndatl1bm403l[2][2] unaligndatl1bm403l[2][1] unaligndatl1bm403l[2][0]
+ unaligndatl1bm403l[3][7] unaligndatl1bm403l[3][6] unaligndatl1bm403l[3][5] unaligndatl1bm403l[3][4]
+ unaligndatl1bm403l[3][3] unaligndatl1bm403l[3][2] unaligndatl1bm403l[3][1] unaligndatl1bm403l[3][0]
+ vcc vss dcu_rotd_byte
Xidcu_rota_byte chunkrotctrlm403l_0_0_[1] chunkrotctrlm403l_0_0_[0] chunkrotctrlm403l_0_1_[1]
+ chunkrotctrlm403l_0_1_[0] chunkrotoutintnobcstm403l_0__0__data[7] chunkrotoutintnobcstm403l_0__0__data[6]
+ chunkrotoutintnobcstm403l_0__0__data[5] chunkrotoutintnobcstm403l_0__0__data[4]
+ chunkrotoutintnobcstm403l_0__0__data[3] chunkrotoutintnobcstm403l_0__0__data[2]
+ chunkrotoutintnobcstm403l_0__0__data[1] chunkrotoutintnobcstm403l_0__0__data[0]
+ chunkrotoutintnobcstm403l_0__1__data[7] chunkrotoutintnobcstm403l_0__1__data[6]
+ chunkrotoutintnobcstm403l_0__1__data[5] chunkrotoutintnobcstm403l_0__1__data[4]
+ chunkrotoutintnobcstm403l_0__1__data[3] chunkrotoutintnobcstm403l_0__1__data[2]
+ chunkrotoutintnobcstm403l_0__1__data[1] chunkrotoutintnobcstm403l_0__1__data[0]
+ chunkrotoutvecnobcstm403l_0__0__data[7] chunkrotoutvecnobcstm403l_0__0__data[6]
+ chunkrotoutvecnobcstm403l_0__0__data[5] chunkrotoutvecnobcstm403l_0__0__data[4]
+ chunkrotoutvecnobcstm403l_0__0__data[3] chunkrotoutvecnobcstm403l_0__0__data[2]
+ chunkrotoutvecnobcstm403l_0__0__data[1] chunkrotoutvecnobcstm403l_0__0__data[0]
+ chunkrotoutvecnobcstm403l_0__1__data[7] chunkrotoutvecnobcstm403l_0__1__data[6]
+ chunkrotoutvecnobcstm403l_0__1__data[5] chunkrotoutvecnobcstm403l_0__1__data[4]
+ chunkrotoutvecnobcstm403l_0__1__data[3] chunkrotoutvecnobcstm403l_0__1__data[2]
+ chunkrotoutvecnobcstm403l_0__1__data[1] chunkrotoutvecnobcstm403l_0__1__data[0]
+ unaligndatl1am403l[0][7] unaligndatl1am403l[0][6] unaligndatl1am403l[0][5] unaligndatl1am403l[0][4]
+ unaligndatl1am403l[0][3] unaligndatl1am403l[0][2] unaligndatl1am403l[0][1] unaligndatl1am403l[0][0]
+ unaligndatl1am403l[1][7] unaligndatl1am403l[1][6] unaligndatl1am403l[1][5] unaligndatl1am403l[1][4]
+ unaligndatl1am403l[1][3] unaligndatl1am403l[1][2] unaligndatl1am403l[1][1] unaligndatl1am403l[1][0]
+ unaligndatl1am403l[2][7] unaligndatl1am403l[2][6] unaligndatl1am403l[2][5] unaligndatl1am403l[2][4]
+ unaligndatl1am403l[2][3] unaligndatl1am403l[2][2] unaligndatl1am403l[2][1] unaligndatl1am403l[2][0]
+ unaligndatl1am403l[3][7] unaligndatl1am403l[3][6] unaligndatl1am403l[3][5] unaligndatl1am403l[3][4]
+ unaligndatl1am403l[3][3] unaligndatl1am403l[3][2] unaligndatl1am403l[3][1] unaligndatl1am403l[3][0]
+ vcc vss dcu_rota_byte
Xidcu_rotd_byte chunkrotctrlm403l_3_0_[1] chunkrotctrlm403l_3_0_[0] chunkrotctrlm403l_3_1_[1]
+ chunkrotctrlm403l_3_1_[0] chunkrotoutintnobcstm403l_3__0__data[7] chunkrotoutintnobcstm403l_3__0__data[6]
+ chunkrotoutintnobcstm403l_3__0__data[5] chunkrotoutintnobcstm403l_3__0__data[4]
+ chunkrotoutintnobcstm403l_3__0__data[3] chunkrotoutintnobcstm403l_3__0__data[2]
+ chunkrotoutintnobcstm403l_3__0__data[1] chunkrotoutintnobcstm403l_3__0__data[0]
+ chunkrotoutintnobcstm403l_3__1__data[7] chunkrotoutintnobcstm403l_3__1__data[6]
+ chunkrotoutintnobcstm403l_3__1__data[5] chunkrotoutintnobcstm403l_3__1__data[4]
+ chunkrotoutintnobcstm403l_3__1__data[3] chunkrotoutintnobcstm403l_3__1__data[2]
+ chunkrotoutintnobcstm403l_3__1__data[1] chunkrotoutintnobcstm403l_3__1__data[0]
+ chunkrotoutvecnobcstm403l_3__0__data[7] chunkrotoutvecnobcstm403l_3__0__data[6]
+ chunkrotoutvecnobcstm403l_3__0__data[5] chunkrotoutvecnobcstm403l_3__0__data[4]
+ chunkrotoutvecnobcstm403l_3__0__data[3] chunkrotoutvecnobcstm403l_3__0__data[2]
+ chunkrotoutvecnobcstm403l_3__0__data[1] chunkrotoutvecnobcstm403l_3__0__data[0]
+ chunkrotoutvecnobcstm403l_3__1__data[7] chunkrotoutvecnobcstm403l_3__1__data[6]
+ chunkrotoutvecnobcstm403l_3__1__data[5] chunkrotoutvecnobcstm403l_3__1__data[4]
+ chunkrotoutvecnobcstm403l_3__1__data[3] chunkrotoutvecnobcstm403l_3__1__data[2]
+ chunkrotoutvecnobcstm403l_3__1__data[1] chunkrotoutvecnobcstm403l_3__1__data[0]
+ rotrdportbrotdm403l[3] rotrdportbrotdm403l[2] rotrdportbrotdm403l[1] rotrdportbrotdm403l[0]
+ unaligndatl1am403l[0][7] unaligndatl1am403l[0][6] unaligndatl1am403l[0][5] unaligndatl1am403l[0][4]
+ unaligndatl1am403l[0][3] unaligndatl1am403l[0][2] unaligndatl1am403l[0][1] unaligndatl1am403l[0][0]
+ unaligndatl1am403l[1][7] unaligndatl1am403l[1][6] unaligndatl1am403l[1][5] unaligndatl1am403l[1][4]
+ unaligndatl1am403l[1][3] unaligndatl1am403l[1][2] unaligndatl1am403l[1][1] unaligndatl1am403l[1][0]
+ unaligndatl1am403l[2][7] unaligndatl1am403l[2][6] unaligndatl1am403l[2][5] unaligndatl1am403l[2][4]
+ unaligndatl1am403l[2][3] unaligndatl1am403l[2][2] unaligndatl1am403l[2][1] unaligndatl1am403l[2][0]
+ unaligndatl1am403l[3][7] unaligndatl1am403l[3][6] unaligndatl1am403l[3][5] unaligndatl1am403l[3][4]
+ unaligndatl1am403l[3][3] unaligndatl1am403l[3][2] unaligndatl1am403l[3][1] unaligndatl1am403l[3][0]
+ unaligndatl1bm403l[0][7] unaligndatl1bm403l[0][6] unaligndatl1bm403l[0][5] unaligndatl1bm403l[0][4]
+ unaligndatl1bm403l[0][3] unaligndatl1bm403l[0][2] unaligndatl1bm403l[0][1] unaligndatl1bm403l[0][0]
+ unaligndatl1bm403l[1][7] unaligndatl1bm403l[1][6] unaligndatl1bm403l[1][5] unaligndatl1bm403l[1][4]
+ unaligndatl1bm403l[1][3] unaligndatl1bm403l[1][2] unaligndatl1bm403l[1][1] unaligndatl1bm403l[1][0]
+ unaligndatl1bm403l[2][7] unaligndatl1bm403l[2][6] unaligndatl1bm403l[2][5] unaligndatl1bm403l[2][4]
+ unaligndatl1bm403l[2][3] unaligndatl1bm403l[2][2] unaligndatl1bm403l[2][1] unaligndatl1bm403l[2][0]
+ unaligndatl1bm403l[3][7] unaligndatl1bm403l[3][6] unaligndatl1bm403l[3][5] unaligndatl1bm403l[3][4]
+ unaligndatl1bm403l[3][3] unaligndatl1bm403l[3][2] unaligndatl1bm403l[3][1] unaligndatl1bm403l[3][0]
+ vcc vss dcu_rotd_byte
Xidcu_rotc_byte chunkrotctrlm403l_2_0_[1] chunkrotctrlm403l_2_0_[0] chunkrotctrlm403l_2_1_[1]
+ chunkrotctrlm403l_2_1_[0] chunkrotoutintnobcstm403l_2__0__data[7] chunkrotoutintnobcstm403l_2__0__data[6]
+ chunkrotoutintnobcstm403l_2__0__data[5] chunkrotoutintnobcstm403l_2__0__data[4]
+ chunkrotoutintnobcstm403l_2__0__data[3] chunkrotoutintnobcstm403l_2__0__data[2]
+ chunkrotoutintnobcstm403l_2__0__data[1] chunkrotoutintnobcstm403l_2__0__data[0]
+ chunkrotoutintnobcstm403l_2__1__data[7] chunkrotoutintnobcstm403l_2__1__data[6]
+ chunkrotoutintnobcstm403l_2__1__data[5] chunkrotoutintnobcstm403l_2__1__data[4]
+ chunkrotoutintnobcstm403l_2__1__data[3] chunkrotoutintnobcstm403l_2__1__data[2]
+ chunkrotoutintnobcstm403l_2__1__data[1] chunkrotoutintnobcstm403l_2__1__data[0]
+ chunkrotoutvecnobcstm403l_2__0__data[7] chunkrotoutvecnobcstm403l_2__0__data[6]
+ chunkrotoutvecnobcstm403l_2__0__data[5] chunkrotoutvecnobcstm403l_2__0__data[4]
+ chunkrotoutvecnobcstm403l_2__0__data[3] chunkrotoutvecnobcstm403l_2__0__data[2]
+ chunkrotoutvecnobcstm403l_2__0__data[1] chunkrotoutvecnobcstm403l_2__0__data[0]
+ chunkrotoutvecnobcstm403l_2__1__data[7] chunkrotoutvecnobcstm403l_2__1__data[6]
+ chunkrotoutvecnobcstm403l_2__1__data[5] chunkrotoutvecnobcstm403l_2__1__data[4]
+ chunkrotoutvecnobcstm403l_2__1__data[3] chunkrotoutvecnobcstm403l_2__1__data[2]
+ chunkrotoutvecnobcstm403l_2__1__data[1] chunkrotoutvecnobcstm403l_2__1__data[0]
+ unaligndatl1bm403l[0][7] unaligndatl1bm403l[0][6] unaligndatl1bm403l[0][5] unaligndatl1bm403l[0][4]
+ unaligndatl1bm403l[0][3] unaligndatl1bm403l[0][2] unaligndatl1bm403l[0][1] unaligndatl1bm403l[0][0]
+ unaligndatl1bm403l[1][7] unaligndatl1bm403l[1][6] unaligndatl1bm403l[1][5] unaligndatl1bm403l[1][4]
+ unaligndatl1bm403l[1][3] unaligndatl1bm403l[1][2] unaligndatl1bm403l[1][1] unaligndatl1bm403l[1][0]
+ unaligndatl1bm403l[2][7] unaligndatl1bm403l[2][6] unaligndatl1bm403l[2][5] unaligndatl1bm403l[2][4]
+ unaligndatl1bm403l[2][3] unaligndatl1bm403l[2][2] unaligndatl1bm403l[2][1] unaligndatl1bm403l[2][0]
+ unaligndatl1bm403l[3][7] unaligndatl1bm403l[3][6] unaligndatl1bm403l[3][5] unaligndatl1bm403l[3][4]
+ unaligndatl1bm403l[3][3] unaligndatl1bm403l[3][2] unaligndatl1bm403l[3][1] unaligndatl1bm403l[3][0]
+ vcc vss dcu_rotc_byte
Xidcu_store_rot_byte clkanystorev4034ml_rep fscan_clkungate_rep stchunkrotctrlm403h_0_[1]
+ stchunkrotctrlm403h_0_[0] stchunkrotctrlm403h_1_[1] stchunkrotctrlm403h_1_[0]
+ stchunkrotctrlm403h_2_[1] stchunkrotctrlm403h_2_[0] stchunkrotctrlm403h_3_[1]
+ stchunkrotctrlm403h_3_[0] strotalgnbdatchunkm403h[0][7] strotalgnbdatchunkm403h[0][6]
+ strotalgnbdatchunkm403h[0][5] strotalgnbdatchunkm403h[0][4] strotalgnbdatchunkm403h[0][3]
+ strotalgnbdatchunkm403h[0][2] strotalgnbdatchunkm403h[0][1] strotalgnbdatchunkm403h[0][0]
+ strotalgnbdatchunkm403h[1][7] strotalgnbdatchunkm403h[1][6] strotalgnbdatchunkm403h[1][5]
+ strotalgnbdatchunkm403h[1][4] strotalgnbdatchunkm403h[1][3] strotalgnbdatchunkm403h[1][2]
+ strotalgnbdatchunkm403h[1][1] strotalgnbdatchunkm403h[1][0] strotalgnbdatchunkm403h[2][7]
+ strotalgnbdatchunkm403h[2][6] strotalgnbdatchunkm403h[2][5] strotalgnbdatchunkm403h[2][4]
+ strotalgnbdatchunkm403h[2][3] strotalgnbdatchunkm403h[2][2] strotalgnbdatchunkm403h[2][1]
+ strotalgnbdatchunkm403h[2][0] strotalgnbdatchunkm403h[3][7] strotalgnbdatchunkm403h[3][6]
+ strotalgnbdatchunkm403h[3][5] strotalgnbdatchunkm403h[3][4] strotalgnbdatchunkm403h[3][3]
+ strotalgnbdatchunkm403h[3][2] strotalgnbdatchunkm403h[3][1] strotalgnbdatchunkm403h[3][0]
+ strotalgnbdatm403l_0_[7] strotalgnbdatm403l_0_[6] strotalgnbdatm403l_0_[5] strotalgnbdatm403l_0_[4]
+ strotalgnbdatm403l_0_[3] strotalgnbdatm403l_0_[2] strotalgnbdatm403l_0_[1] strotalgnbdatm403l_0_[0]
+ strotalgnbdatm403l_1_[7] strotalgnbdatm403l_1_[6] strotalgnbdatm403l_1_[5] strotalgnbdatm403l_1_[4]
+ strotalgnbdatm403l_1_[3] strotalgnbdatm403l_1_[2] strotalgnbdatm403l_1_[1] strotalgnbdatm403l_1_[0]
+ strotalgnbdatm403l_2_[7] strotalgnbdatm403l_2_[6] strotalgnbdatm403l_2_[5] strotalgnbdatm403l_2_[4]
+ strotalgnbdatm403l_2_[3] strotalgnbdatm403l_2_[2] strotalgnbdatm403l_2_[1] strotalgnbdatm403l_2_[0]
+ strotalgnbdatm403l_3_[7] strotalgnbdatm403l_3_[6] strotalgnbdatm403l_3_[5] strotalgnbdatm403l_3_[4]
+ strotalgnbdatm403l_3_[3] strotalgnbdatm403l_3_[2] strotalgnbdatm403l_3_[1] strotalgnbdatm403l_3_[0]
+ strotclkenm402l[3] strotclkenm402l[2] strotclkenm402l[1] strotclkenm402l[0] vcc
+ vss dcu_store_rot_byte
Xgnac0 mclk vcc vss i0mydp122ub1n00x5
Xgnac1 lcpctrl_fd[0] vcc vss i0mydp122ub1n00x5
Xgnac2 fscan_clkungate vcc vss i0mydp122ub1n00x5
Xgnac3 lcpctrl_rd[0] vcc vss i0mydp122ub1n00x5
Xgnac4 unaligndatl1bm403l[0][7] vcc vss i0mydp122ub1n00x5
Xgnac5 unaligndatl1bm403l[0][1] vcc vss i0mydp122ub1n00x5
Xgnac6 unaligndatl1bm403l[0][5] vcc vss i0mydp122ub1n00x5
Xgnac7 unaligndatl1bm403l[0][3] vcc vss i0mydp122ub1n00x5
Xirep0 fscan_clkungate_rep signal_elevate_fscan_clkungate vcc vss i0mbfn000ab1n18x5
.ENDS

.SUBCKT dcchunkrotd chunkrotctrlm403l_0__0_[1] chunkrotctrlm403l_0__0_[0] chunkrotctrlm403l_0__1_[1]
+ chunkrotctrlm403l_0__1_[0] chunkrotctrlm403l_1__0_[1] chunkrotctrlm403l_1__0_[0]
+ chunkrotctrlm403l_1__1_[1] chunkrotctrlm403l_1__1_[0] chunkrotctrlm403l_2__0_[1]
+ chunkrotctrlm403l_2__0_[0] chunkrotctrlm403l_2__1_[1] chunkrotctrlm403l_2__1_[0]
+ chunkrotctrlm403l_3__0_[1] chunkrotctrlm403l_3__0_[0] chunkrotctrlm403l_3__1_[1]
+ chunkrotctrlm403l_3__1_[0] chunkrotoutintnobcstm403l_0__0__data[7] chunkrotoutintnobcstm403l_0__0__data[6]
+ chunkrotoutintnobcstm403l_0__0__data[5] chunkrotoutintnobcstm403l_0__0__data[4]
+ chunkrotoutintnobcstm403l_0__0__data[3] chunkrotoutintnobcstm403l_0__0__data[2]
+ chunkrotoutintnobcstm403l_0__0__data[1] chunkrotoutintnobcstm403l_0__0__data[0]
+ chunkrotoutintnobcstm403l_0__1__data[7] chunkrotoutintnobcstm403l_0__1__data[6]
+ chunkrotoutintnobcstm403l_0__1__data[5] chunkrotoutintnobcstm403l_0__1__data[4]
+ chunkrotoutintnobcstm403l_0__1__data[3] chunkrotoutintnobcstm403l_0__1__data[2]
+ chunkrotoutintnobcstm403l_0__1__data[1] chunkrotoutintnobcstm403l_0__1__data[0]
+ chunkrotoutintnobcstm403l_1__0__data[7] chunkrotoutintnobcstm403l_1__0__data[6]
+ chunkrotoutintnobcstm403l_1__0__data[5] chunkrotoutintnobcstm403l_1__0__data[4]
+ chunkrotoutintnobcstm403l_1__0__data[3] chunkrotoutintnobcstm403l_1__0__data[2]
+ chunkrotoutintnobcstm403l_1__0__data[1] chunkrotoutintnobcstm403l_1__0__data[0]
+ chunkrotoutintnobcstm403l_1__1__data[7] chunkrotoutintnobcstm403l_1__1__data[6]
+ chunkrotoutintnobcstm403l_1__1__data[5] chunkrotoutintnobcstm403l_1__1__data[4]
+ chunkrotoutintnobcstm403l_1__1__data[3] chunkrotoutintnobcstm403l_1__1__data[2]
+ chunkrotoutintnobcstm403l_1__1__data[1] chunkrotoutintnobcstm403l_1__1__data[0]
+ chunkrotoutintnobcstm403l_2__0__data[7] chunkrotoutintnobcstm403l_2__0__data[6]
+ chunkrotoutintnobcstm403l_2__0__data[5] chunkrotoutintnobcstm403l_2__0__data[4]
+ chunkrotoutintnobcstm403l_2__0__data[3] chunkrotoutintnobcstm403l_2__0__data[2]
+ chunkrotoutintnobcstm403l_2__0__data[1] chunkrotoutintnobcstm403l_2__0__data[0]
+ chunkrotoutintnobcstm403l_2__1__data[7] chunkrotoutintnobcstm403l_2__1__data[6]
+ chunkrotoutintnobcstm403l_2__1__data[5] chunkrotoutintnobcstm403l_2__1__data[4]
+ chunkrotoutintnobcstm403l_2__1__data[3] chunkrotoutintnobcstm403l_2__1__data[2]
+ chunkrotoutintnobcstm403l_2__1__data[1] chunkrotoutintnobcstm403l_2__1__data[0]
+ chunkrotoutintnobcstm403l_3__0__data[7] chunkrotoutintnobcstm403l_3__0__data[6]
+ chunkrotoutintnobcstm403l_3__0__data[5] chunkrotoutintnobcstm403l_3__0__data[4]
+ chunkrotoutintnobcstm403l_3__0__data[3] chunkrotoutintnobcstm403l_3__0__data[2]
+ chunkrotoutintnobcstm403l_3__0__data[1] chunkrotoutintnobcstm403l_3__0__data[0]
+ chunkrotoutintnobcstm403l_3__1__data[7] chunkrotoutintnobcstm403l_3__1__data[6]
+ chunkrotoutintnobcstm403l_3__1__data[5] chunkrotoutintnobcstm403l_3__1__data[4]
+ chunkrotoutintnobcstm403l_3__1__data[3] chunkrotoutintnobcstm403l_3__1__data[2]
+ chunkrotoutintnobcstm403l_3__1__data[1] chunkrotoutintnobcstm403l_3__1__data[0]
+ chunkrotoutvecnobcstm403l_0__0__data[7] chunkrotoutvecnobcstm403l_0__0__data[6]
+ chunkrotoutvecnobcstm403l_0__0__data[5] chunkrotoutvecnobcstm403l_0__0__data[4]
+ chunkrotoutvecnobcstm403l_0__0__data[3] chunkrotoutvecnobcstm403l_0__0__data[2]
+ chunkrotoutvecnobcstm403l_0__0__data[1] chunkrotoutvecnobcstm403l_0__0__data[0]
+ chunkrotoutvecnobcstm403l_0__1__data[7] chunkrotoutvecnobcstm403l_0__1__data[6]
+ chunkrotoutvecnobcstm403l_0__1__data[5] chunkrotoutvecnobcstm403l_0__1__data[4]
+ chunkrotoutvecnobcstm403l_0__1__data[3] chunkrotoutvecnobcstm403l_0__1__data[2]
+ chunkrotoutvecnobcstm403l_0__1__data[1] chunkrotoutvecnobcstm403l_0__1__data[0]
+ chunkrotoutvecnobcstm403l_1__0__data[7] chunkrotoutvecnobcstm403l_1__0__data[6]
+ chunkrotoutvecnobcstm403l_1__0__data[5] chunkrotoutvecnobcstm403l_1__0__data[4]
+ chunkrotoutvecnobcstm403l_1__0__data[3] chunkrotoutvecnobcstm403l_1__0__data[2]
+ chunkrotoutvecnobcstm403l_1__0__data[1] chunkrotoutvecnobcstm403l_1__0__data[0]
+ chunkrotoutvecnobcstm403l_1__1__data[7] chunkrotoutvecnobcstm403l_1__1__data[6]
+ chunkrotoutvecnobcstm403l_1__1__data[5] chunkrotoutvecnobcstm403l_1__1__data[4]
+ chunkrotoutvecnobcstm403l_1__1__data[3] chunkrotoutvecnobcstm403l_1__1__data[2]
+ chunkrotoutvecnobcstm403l_1__1__data[1] chunkrotoutvecnobcstm403l_1__1__data[0]
+ chunkrotoutvecnobcstm403l_2__0__data[7] chunkrotoutvecnobcstm403l_2__0__data[6]
+ chunkrotoutvecnobcstm403l_2__0__data[5] chunkrotoutvecnobcstm403l_2__0__data[4]
+ chunkrotoutvecnobcstm403l_2__0__data[3] chunkrotoutvecnobcstm403l_2__0__data[2]
+ chunkrotoutvecnobcstm403l_2__0__data[1] chunkrotoutvecnobcstm403l_2__0__data[0]
+ chunkrotoutvecnobcstm403l_2__1__data[7] chunkrotoutvecnobcstm403l_2__1__data[6]
+ chunkrotoutvecnobcstm403l_2__1__data[5] chunkrotoutvecnobcstm403l_2__1__data[4]
+ chunkrotoutvecnobcstm403l_2__1__data[3] chunkrotoutvecnobcstm403l_2__1__data[2]
+ chunkrotoutvecnobcstm403l_2__1__data[1] chunkrotoutvecnobcstm403l_2__1__data[0]
+ chunkrotoutvecnobcstm403l_3__0__data[7] chunkrotoutvecnobcstm403l_3__0__data[6]
+ chunkrotoutvecnobcstm403l_3__0__data[5] chunkrotoutvecnobcstm403l_3__0__data[4]
+ chunkrotoutvecnobcstm403l_3__0__data[3] chunkrotoutvecnobcstm403l_3__0__data[2]
+ chunkrotoutvecnobcstm403l_3__0__data[1] chunkrotoutvecnobcstm403l_3__0__data[0]
+ chunkrotoutvecnobcstm403l_3__1__data[7] chunkrotoutvecnobcstm403l_3__1__data[6]
+ chunkrotoutvecnobcstm403l_3__1__data[5] chunkrotoutvecnobcstm403l_3__1__data[4]
+ chunkrotoutvecnobcstm403l_3__1__data[3] chunkrotoutvecnobcstm403l_3__1__data[2]
+ chunkrotoutvecnobcstm403l_3__1__data[1] chunkrotoutvecnobcstm403l_3__1__data[0]
+ clkanystorev4034ml fscan_clkungate lcpctrl_fd[0] lcpctrl_rd[0] rotrdportbrotbm403l[3]
+ rotrdportbrotbm403l[2] rotrdportbrotbm403l[1] rotrdportbrotbm403l[0] rotrdportbrotdm403l[3]
+ rotrdportbrotdm403l[2] rotrdportbrotdm403l[1] rotrdportbrotdm403l[0] signal_elevator_fscan_clkungate
+ signal_elevator_strotclkenm402l[3] signal_elevator_strotclkenm402l[2] signal_elevator_strotclkenm402l[1]
+ signal_elevator_strotclkenm402l[0] stchunkrotctrlm403h_0_[1] stchunkrotctrlm403h_0_[0]
+ stchunkrotctrlm403h_1_[1] stchunkrotctrlm403h_1_[0] stchunkrotctrlm403h_2_[1]
+ stchunkrotctrlm403h_2_[0] stchunkrotctrlm403h_3_[1] stchunkrotctrlm403h_3_[0]
+ strotalgnbdatchunkm403h_0__data[7] strotalgnbdatchunkm403h_0__data[6] strotalgnbdatchunkm403h_0__data[5]
+ strotalgnbdatchunkm403h_0__data[4] strotalgnbdatchunkm403h_0__data[3] strotalgnbdatchunkm403h_0__data[2]
+ strotalgnbdatchunkm403h_0__data[1] strotalgnbdatchunkm403h_0__data[0] strotalgnbdatchunkm403h_1__data[7]
+ strotalgnbdatchunkm403h_1__data[6] strotalgnbdatchunkm403h_1__data[5] strotalgnbdatchunkm403h_1__data[4]
+ strotalgnbdatchunkm403h_1__data[3] strotalgnbdatchunkm403h_1__data[2] strotalgnbdatchunkm403h_1__data[1]
+ strotalgnbdatchunkm403h_1__data[0] strotalgnbdatchunkm403h_2__data[7] strotalgnbdatchunkm403h_2__data[6]
+ strotalgnbdatchunkm403h_2__data[5] strotalgnbdatchunkm403h_2__data[4] strotalgnbdatchunkm403h_2__data[3]
+ strotalgnbdatchunkm403h_2__data[2] strotalgnbdatchunkm403h_2__data[1] strotalgnbdatchunkm403h_2__data[0]
+ strotalgnbdatchunkm403h_3__data[7] strotalgnbdatchunkm403h_3__data[6] strotalgnbdatchunkm403h_3__data[5]
+ strotalgnbdatchunkm403h_3__data[4] strotalgnbdatchunkm403h_3__data[3] strotalgnbdatchunkm403h_3__data[2]
+ strotalgnbdatchunkm403h_3__data[1] strotalgnbdatchunkm403h_3__data[0] strotalgnbdatm403l_0__data[7]
+ strotalgnbdatm403l_0__data[6] strotalgnbdatm403l_0__data[5] strotalgnbdatm403l_0__data[4]
+ strotalgnbdatm403l_0__data[3] strotalgnbdatm403l_0__data[2] strotalgnbdatm403l_0__data[1]
+ strotalgnbdatm403l_0__data[0] strotalgnbdatm403l_1__data[7] strotalgnbdatm403l_1__data[6]
+ strotalgnbdatm403l_1__data[5] strotalgnbdatm403l_1__data[4] strotalgnbdatm403l_1__data[3]
+ strotalgnbdatm403l_1__data[2] strotalgnbdatm403l_1__data[1] strotalgnbdatm403l_1__data[0]
+ strotalgnbdatm403l_2__data[7] strotalgnbdatm403l_2__data[6] strotalgnbdatm403l_2__data[5]
+ strotalgnbdatm403l_2__data[4] strotalgnbdatm403l_2__data[3] strotalgnbdatm403l_2__data[2]
+ strotalgnbdatm403l_2__data[1] strotalgnbdatm403l_2__data[0] strotalgnbdatm403l_3__data[7]
+ strotalgnbdatm403l_3__data[6] strotalgnbdatm403l_3__data[5] strotalgnbdatm403l_3__data[4]
+ strotalgnbdatm403l_3__data[3] strotalgnbdatm403l_3__data[2] strotalgnbdatm403l_3__data[1]
+ strotalgnbdatm403l_3__data[0] strotclkenm402l[3] strotclkenm402l[2] strotclkenm402l[1]
+ strotclkenm402l[0] unaligndatportam403l_0__data[7] unaligndatportam403l_0__data[6]
+ unaligndatportam403l_0__data[5] unaligndatportam403l_0__data[4] unaligndatportam403l_0__data[3]
+ unaligndatportam403l_0__data[2] unaligndatportam403l_0__data[1] unaligndatportam403l_0__data[0]
+ unaligndatportam403l_1__data[7] unaligndatportam403l_1__data[6] unaligndatportam403l_1__data[5]
+ unaligndatportam403l_1__data[4] unaligndatportam403l_1__data[3] unaligndatportam403l_1__data[2]
+ unaligndatportam403l_1__data[1] unaligndatportam403l_1__data[0] unaligndatportam403l_2__data[7]
+ unaligndatportam403l_2__data[6] unaligndatportam403l_2__data[5] unaligndatportam403l_2__data[4]
+ unaligndatportam403l_2__data[3] unaligndatportam403l_2__data[2] unaligndatportam403l_2__data[1]
+ unaligndatportam403l_2__data[0] unaligndatportam403l_3__data[7] unaligndatportam403l_3__data[6]
+ unaligndatportam403l_3__data[5] unaligndatportam403l_3__data[4] unaligndatportam403l_3__data[3]
+ unaligndatportam403l_3__data[2] unaligndatportam403l_3__data[1] unaligndatportam403l_3__data[0]
+ unaligndatportbm403l_0__data[7] unaligndatportbm403l_0__data[6] unaligndatportbm403l_0__data[5]
+ unaligndatportbm403l_0__data[4] unaligndatportbm403l_0__data[3] unaligndatportbm403l_0__data[2]
+ unaligndatportbm403l_0__data[1] unaligndatportbm403l_0__data[0] unaligndatportbm403l_1__data[7]
+ unaligndatportbm403l_1__data[6] unaligndatportbm403l_1__data[5] unaligndatportbm403l_1__data[4]
+ unaligndatportbm403l_1__data[3] unaligndatportbm403l_1__data[2] unaligndatportbm403l_1__data[1]
+ unaligndatportbm403l_1__data[0] unaligndatportbm403l_2__data[7] unaligndatportbm403l_2__data[6]
+ unaligndatportbm403l_2__data[5] unaligndatportbm403l_2__data[4] unaligndatportbm403l_2__data[3]
+ unaligndatportbm403l_2__data[2] unaligndatportbm403l_2__data[1] unaligndatportbm403l_2__data[0]
+ unaligndatportbm403l_3__data[7] unaligndatportbm403l_3__data[6] unaligndatportbm403l_3__data[5]
+ unaligndatportbm403l_3__data[4] unaligndatportbm403l_3__data[3] unaligndatportbm403l_3__data[2]
+ unaligndatportbm403l_3__data[1] unaligndatportbm403l_3__data[0] vcc vss
Xdcchunkrotd_dcap_container vcc vss dcchunkrotd_dcap_container
Xgnac15 unaligndatportam403l_1__data[4] vcc vss i0mydp122ub1n00x5
Xgnac14 unaligndatportam403l_1__data[5] vcc vss i0mydp122ub1n00x5
Xgnac13 unaligndatportam403l_1__data[7] vcc vss i0mydp122ub1n00x5
Xgnac12 unaligndatportbm403l_3__data[7] vcc vss i0mydp122ub1n00x5
Xgnac11 unaligndatportbm403l_2__data[3] vcc vss i0mydp122ub1n00x5
Xgnac10 unaligndatportbm403l_2__data[5] vcc vss i0mydp122ub1n00x5
Xgnac9 unaligndatportam403l_1__data[6] vcc vss i0mydp122ub1n00x5
Xgnac8 unaligndatportam403l_1__data[1] vcc vss i0mydp122ub1n00x5
Xgnac7 unaligndatportam403l_1__data[0] vcc vss i0mydp122ub1n00x5
Xgnac6 unaligndatportam403l_1__data[3] vcc vss i0mydp122ub1n00x5
Xgnac5 unaligndatportbm403l_2__data[7] vcc vss i0mydp122ub1n00x5
Xgnac4 unaligndatportbm403l_3__data[1] vcc vss i0mydp122ub1n00x5
Xgnac3 unaligndatportam403l_1__data[2] vcc vss i0mydp122ub1n00x5
Xgnac2 unaligndatportbm403l_3__data[3] vcc vss i0mydp122ub1n00x5
Xgnac1 unaligndatportbm403l_3__data[5] vcc vss i0mydp122ub1n00x5
Xgnac0 unaligndatportbm403l_2__data[1] vcc vss i0mydp122ub1n00x5
Xidcchunk_rot chunkrotctrlm403l_0__0_[1] chunkrotctrlm403l_0__0_[0] chunkrotctrlm403l_0__1_[1]
+ chunkrotctrlm403l_0__1_[0] chunkrotctrlm403l_1__0_[1] chunkrotctrlm403l_1__0_[0]
+ chunkrotctrlm403l_1__1_[1] chunkrotctrlm403l_1__1_[0] chunkrotctrlm403l_2__0_[1]
+ chunkrotctrlm403l_2__0_[0] chunkrotctrlm403l_2__1_[1] chunkrotctrlm403l_2__1_[0]
+ chunkrotctrlm403l_3__0_[1] chunkrotctrlm403l_3__0_[0] chunkrotctrlm403l_3__1_[1]
+ chunkrotctrlm403l_3__1_[0] chunkrotoutintnobcstm403l_0__0__data[7] chunkrotoutintnobcstm403l_0__0__data[6]
+ chunkrotoutintnobcstm403l_0__0__data[5] chunkrotoutintnobcstm403l_0__0__data[4]
+ chunkrotoutintnobcstm403l_0__0__data[3] chunkrotoutintnobcstm403l_0__0__data[2]
+ chunkrotoutintnobcstm403l_0__0__data[1] chunkrotoutintnobcstm403l_0__0__data[0]
+ chunkrotoutintnobcstm403l_0__1__data[7] chunkrotoutintnobcstm403l_0__1__data[6]
+ chunkrotoutintnobcstm403l_0__1__data[5] chunkrotoutintnobcstm403l_0__1__data[4]
+ chunkrotoutintnobcstm403l_0__1__data[3] chunkrotoutintnobcstm403l_0__1__data[2]
+ chunkrotoutintnobcstm403l_0__1__data[1] chunkrotoutintnobcstm403l_0__1__data[0]
+ chunkrotoutintnobcstm403l_1__0__data[7] chunkrotoutintnobcstm403l_1__0__data[6]
+ chunkrotoutintnobcstm403l_1__0__data[5] chunkrotoutintnobcstm403l_1__0__data[4]
+ chunkrotoutintnobcstm403l_1__0__data[3] chunkrotoutintnobcstm403l_1__0__data[2]
+ chunkrotoutintnobcstm403l_1__0__data[1] chunkrotoutintnobcstm403l_1__0__data[0]
+ chunkrotoutintnobcstm403l_1__1__data[7] chunkrotoutintnobcstm403l_1__1__data[6]
+ chunkrotoutintnobcstm403l_1__1__data[5] chunkrotoutintnobcstm403l_1__1__data[4]
+ chunkrotoutintnobcstm403l_1__1__data[3] chunkrotoutintnobcstm403l_1__1__data[2]
+ chunkrotoutintnobcstm403l_1__1__data[1] chunkrotoutintnobcstm403l_1__1__data[0]
+ chunkrotoutintnobcstm403l_2__0__data[7] chunkrotoutintnobcstm403l_2__0__data[6]
+ chunkrotoutintnobcstm403l_2__0__data[5] chunkrotoutintnobcstm403l_2__0__data[4]
+ chunkrotoutintnobcstm403l_2__0__data[3] chunkrotoutintnobcstm403l_2__0__data[2]
+ chunkrotoutintnobcstm403l_2__0__data[1] chunkrotoutintnobcstm403l_2__0__data[0]
+ chunkrotoutintnobcstm403l_2__1__data[7] chunkrotoutintnobcstm403l_2__1__data[6]
+ chunkrotoutintnobcstm403l_2__1__data[5] chunkrotoutintnobcstm403l_2__1__data[4]
+ chunkrotoutintnobcstm403l_2__1__data[3] chunkrotoutintnobcstm403l_2__1__data[2]
+ chunkrotoutintnobcstm403l_2__1__data[1] chunkrotoutintnobcstm403l_2__1__data[0]
+ chunkrotoutintnobcstm403l_3__0__data[7] chunkrotoutintnobcstm403l_3__0__data[6]
+ chunkrotoutintnobcstm403l_3__0__data[5] chunkrotoutintnobcstm403l_3__0__data[4]
+ chunkrotoutintnobcstm403l_3__0__data[3] chunkrotoutintnobcstm403l_3__0__data[2]
+ chunkrotoutintnobcstm403l_3__0__data[1] chunkrotoutintnobcstm403l_3__0__data[0]
+ chunkrotoutintnobcstm403l_3__1__data[7] chunkrotoutintnobcstm403l_3__1__data[6]
+ chunkrotoutintnobcstm403l_3__1__data[5] chunkrotoutintnobcstm403l_3__1__data[4]
+ chunkrotoutintnobcstm403l_3__1__data[3] chunkrotoutintnobcstm403l_3__1__data[2]
+ chunkrotoutintnobcstm403l_3__1__data[1] chunkrotoutintnobcstm403l_3__1__data[0]
+ chunkrotoutvecnobcstm403l_0__0__data[7] chunkrotoutvecnobcstm403l_0__0__data[6]
+ chunkrotoutvecnobcstm403l_0__0__data[5] chunkrotoutvecnobcstm403l_0__0__data[4]
+ chunkrotoutvecnobcstm403l_0__0__data[3] chunkrotoutvecnobcstm403l_0__0__data[2]
+ chunkrotoutvecnobcstm403l_0__0__data[1] chunkrotoutvecnobcstm403l_0__0__data[0]
+ chunkrotoutvecnobcstm403l_0__1__data[7] chunkrotoutvecnobcstm403l_0__1__data[6]
+ chunkrotoutvecnobcstm403l_0__1__data[5] chunkrotoutvecnobcstm403l_0__1__data[4]
+ chunkrotoutvecnobcstm403l_0__1__data[3] chunkrotoutvecnobcstm403l_0__1__data[2]
+ chunkrotoutvecnobcstm403l_0__1__data[1] chunkrotoutvecnobcstm403l_0__1__data[0]
+ chunkrotoutvecnobcstm403l_1__0__data[7] chunkrotoutvecnobcstm403l_1__0__data[6]
+ chunkrotoutvecnobcstm403l_1__0__data[5] chunkrotoutvecnobcstm403l_1__0__data[4]
+ chunkrotoutvecnobcstm403l_1__0__data[3] chunkrotoutvecnobcstm403l_1__0__data[2]
+ chunkrotoutvecnobcstm403l_1__0__data[1] chunkrotoutvecnobcstm403l_1__0__data[0]
+ chunkrotoutvecnobcstm403l_1__1__data[7] chunkrotoutvecnobcstm403l_1__1__data[6]
+ chunkrotoutvecnobcstm403l_1__1__data[5] chunkrotoutvecnobcstm403l_1__1__data[4]
+ chunkrotoutvecnobcstm403l_1__1__data[3] chunkrotoutvecnobcstm403l_1__1__data[2]
+ chunkrotoutvecnobcstm403l_1__1__data[1] chunkrotoutvecnobcstm403l_1__1__data[0]
+ chunkrotoutvecnobcstm403l_2__0__data[7] chunkrotoutvecnobcstm403l_2__0__data[6]
+ chunkrotoutvecnobcstm403l_2__0__data[5] chunkrotoutvecnobcstm403l_2__0__data[4]
+ chunkrotoutvecnobcstm403l_2__0__data[3] chunkrotoutvecnobcstm403l_2__0__data[2]
+ chunkrotoutvecnobcstm403l_2__0__data[1] chunkrotoutvecnobcstm403l_2__0__data[0]
+ chunkrotoutvecnobcstm403l_2__1__data[7] chunkrotoutvecnobcstm403l_2__1__data[6]
+ chunkrotoutvecnobcstm403l_2__1__data[5] chunkrotoutvecnobcstm403l_2__1__data[4]
+ chunkrotoutvecnobcstm403l_2__1__data[3] chunkrotoutvecnobcstm403l_2__1__data[2]
+ chunkrotoutvecnobcstm403l_2__1__data[1] chunkrotoutvecnobcstm403l_2__1__data[0]
+ chunkrotoutvecnobcstm403l_3__0__data[7] chunkrotoutvecnobcstm403l_3__0__data[6]
+ chunkrotoutvecnobcstm403l_3__0__data[5] chunkrotoutvecnobcstm403l_3__0__data[4]
+ chunkrotoutvecnobcstm403l_3__0__data[3] chunkrotoutvecnobcstm403l_3__0__data[2]
+ chunkrotoutvecnobcstm403l_3__0__data[1] chunkrotoutvecnobcstm403l_3__0__data[0]
+ chunkrotoutvecnobcstm403l_3__1__data[7] chunkrotoutvecnobcstm403l_3__1__data[6]
+ chunkrotoutvecnobcstm403l_3__1__data[5] chunkrotoutvecnobcstm403l_3__1__data[4]
+ chunkrotoutvecnobcstm403l_3__1__data[3] chunkrotoutvecnobcstm403l_3__1__data[2]
+ chunkrotoutvecnobcstm403l_3__1__data[1] chunkrotoutvecnobcstm403l_3__1__data[0]
+ fscan_clkungate lcpctrl_fd[0] lcpctrl_rd[0] clkanystorev4034ml rotrdportbrotbm403l[3]
+ rotrdportbrotbm403l[2] rotrdportbrotbm403l[1] rotrdportbrotbm403l[0] rotrdportbrotdm403l[3]
+ rotrdportbrotdm403l[2] rotrdportbrotdm403l[1] rotrdportbrotdm403l[0] signal_elevator_fscan_clkungate
+ stchunkrotctrlm403h_0_[1] stchunkrotctrlm403h_0_[0] stchunkrotctrlm403h_1_[1]
+ stchunkrotctrlm403h_1_[0] stchunkrotctrlm403h_2_[1] stchunkrotctrlm403h_2_[0]
+ stchunkrotctrlm403h_3_[1] stchunkrotctrlm403h_3_[0] strotalgnbdatchunkm403h_0__data[7]
+ strotalgnbdatchunkm403h_0__data[6] strotalgnbdatchunkm403h_0__data[5] strotalgnbdatchunkm403h_0__data[4]
+ strotalgnbdatchunkm403h_0__data[3] strotalgnbdatchunkm403h_0__data[2] strotalgnbdatchunkm403h_0__data[1]
+ strotalgnbdatchunkm403h_0__data[0] strotalgnbdatchunkm403h_1__data[7] strotalgnbdatchunkm403h_1__data[6]
+ strotalgnbdatchunkm403h_1__data[5] strotalgnbdatchunkm403h_1__data[4] strotalgnbdatchunkm403h_1__data[3]
+ strotalgnbdatchunkm403h_1__data[2] strotalgnbdatchunkm403h_1__data[1] strotalgnbdatchunkm403h_1__data[0]
+ strotalgnbdatchunkm403h_2__data[7] strotalgnbdatchunkm403h_2__data[6] strotalgnbdatchunkm403h_2__data[5]
+ strotalgnbdatchunkm403h_2__data[4] strotalgnbdatchunkm403h_2__data[3] strotalgnbdatchunkm403h_2__data[2]
+ strotalgnbdatchunkm403h_2__data[1] strotalgnbdatchunkm403h_2__data[0] strotalgnbdatchunkm403h_3__data[7]
+ strotalgnbdatchunkm403h_3__data[6] strotalgnbdatchunkm403h_3__data[5] strotalgnbdatchunkm403h_3__data[4]
+ strotalgnbdatchunkm403h_3__data[3] strotalgnbdatchunkm403h_3__data[2] strotalgnbdatchunkm403h_3__data[1]
+ strotalgnbdatchunkm403h_3__data[0] strotalgnbdatm403l_0__data[7] strotalgnbdatm403l_0__data[6]
+ strotalgnbdatm403l_0__data[5] strotalgnbdatm403l_0__data[4] strotalgnbdatm403l_0__data[3]
+ strotalgnbdatm403l_0__data[2] strotalgnbdatm403l_0__data[1] strotalgnbdatm403l_0__data[0]
+ strotalgnbdatm403l_1__data[7] strotalgnbdatm403l_1__data[6] strotalgnbdatm403l_1__data[5]
+ strotalgnbdatm403l_1__data[4] strotalgnbdatm403l_1__data[3] strotalgnbdatm403l_1__data[2]
+ strotalgnbdatm403l_1__data[1] strotalgnbdatm403l_1__data[0] strotalgnbdatm403l_2__data[7]
+ strotalgnbdatm403l_2__data[6] strotalgnbdatm403l_2__data[5] strotalgnbdatm403l_2__data[4]
+ strotalgnbdatm403l_2__data[3] strotalgnbdatm403l_2__data[2] strotalgnbdatm403l_2__data[1]
+ strotalgnbdatm403l_2__data[0] strotalgnbdatm403l_3__data[7] strotalgnbdatm403l_3__data[6]
+ strotalgnbdatm403l_3__data[5] strotalgnbdatm403l_3__data[4] strotalgnbdatm403l_3__data[3]
+ strotalgnbdatm403l_3__data[2] strotalgnbdatm403l_3__data[1] strotalgnbdatm403l_3__data[0]
+ strotclkenm402l[3] strotclkenm402l[2] strotclkenm402l[1] strotclkenm402l[0] unaligndatportam403l_0__data[7]
+ unaligndatportam403l_0__data[6] unaligndatportam403l_0__data[5] unaligndatportam403l_0__data[4]
+ unaligndatportam403l_0__data[3] unaligndatportam403l_0__data[2] unaligndatportam403l_0__data[1]
+ unaligndatportam403l_0__data[0] unaligndatportam403l_1__data[7] unaligndatportam403l_1__data[6]
+ unaligndatportam403l_1__data[5] unaligndatportam403l_1__data[4] unaligndatportam403l_1__data[3]
+ unaligndatportam403l_1__data[2] unaligndatportam403l_1__data[1] unaligndatportam403l_1__data[0]
+ unaligndatportam403l_2__data[7] unaligndatportam403l_2__data[6] unaligndatportam403l_2__data[5]
+ unaligndatportam403l_2__data[4] unaligndatportam403l_2__data[3] unaligndatportam403l_2__data[2]
+ unaligndatportam403l_2__data[1] unaligndatportam403l_2__data[0] unaligndatportam403l_3__data[7]
+ unaligndatportam403l_3__data[6] unaligndatportam403l_3__data[5] unaligndatportam403l_3__data[4]
+ unaligndatportam403l_3__data[3] unaligndatportam403l_3__data[2] unaligndatportam403l_3__data[1]
+ unaligndatportam403l_3__data[0] unaligndatportbm403l_0__data[7] unaligndatportbm403l_0__data[6]
+ unaligndatportbm403l_0__data[5] unaligndatportbm403l_0__data[4] unaligndatportbm403l_0__data[3]
+ unaligndatportbm403l_0__data[2] unaligndatportbm403l_0__data[1] unaligndatportbm403l_0__data[0]
+ unaligndatportbm403l_1__data[7] unaligndatportbm403l_1__data[6] unaligndatportbm403l_1__data[5]
+ unaligndatportbm403l_1__data[4] unaligndatportbm403l_1__data[3] unaligndatportbm403l_1__data[2]
+ unaligndatportbm403l_1__data[1] unaligndatportbm403l_1__data[0] unaligndatportbm403l_2__data[7]
+ unaligndatportbm403l_2__data[6] unaligndatportbm403l_2__data[5] unaligndatportbm403l_2__data[4]
+ unaligndatportbm403l_2__data[3] unaligndatportbm403l_2__data[2] unaligndatportbm403l_2__data[1]
+ unaligndatportbm403l_2__data[0] unaligndatportbm403l_3__data[7] unaligndatportbm403l_3__data[6]
+ unaligndatportbm403l_3__data[5] unaligndatportbm403l_3__data[4] unaligndatportbm403l_3__data[3]
+ unaligndatportbm403l_3__data[2] unaligndatportbm403l_3__data[1] unaligndatportbm403l_3__data[0]
+ vcc vss dcchunk_rot
Xstrotclkenm402l[3]_buff strotclkenm402l[3] signal_elevator_strotclkenm402l[3] vcc
+ vss i0mbfn000ab1n18x5
Xstrotclkenm402l[1]_buff strotclkenm402l[1] signal_elevator_strotclkenm402l[1] vcc
+ vss i0mbfn000ab1n18x5
Xdcchunkrotd_spare_container vcc vss dcchunkrotd_spare_container
Xdcchunkrotd_bonus_container vcc vss dcchunkrotd_bonus_container
Xstrotclkenm402l[2]_buff strotclkenm402l[2] signal_elevator_strotclkenm402l[2] vcc
+ vss i0mbfn000ab1n18x5
Xstrotclkenm402l[0]_buff strotclkenm402l[0] signal_elevator_strotclkenm402l[0] vcc
+ vss i0mbfn000ab1n18x5
Xgnac16 unaligndatportam403l_2__data[1] vcc vss i0mydp122ub1n00x5
Xgnac17 unaligndatportam403l_2__data[7] vcc vss i0mydp122ub1n00x5
Xgnac18 unaligndatportam403l_2__data[3] vcc vss i0mydp122ub1n00x5
Xgnac19 unaligndatportam403l_2__data[5] vcc vss i0mydp122ub1n00x5
.ENDS

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mand002ab1n12x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mand002ab1n09x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0maoi022ab1n03x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0maoi022ab1n06x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0maoi022ab1n09x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mbfn000ab1n21x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mbfn000ab1n03x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mbfn000ab1n18x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mbfn000ab1n09x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0minv000ab1n21x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0minv000ab1n06x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0minv000ab1n03x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0minv000ab1n04x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0minv000ab1n18x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0minv000ab1n24x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mmdn022ab1n06x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mnand02ab1n12x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mnand02ac1n03x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mcilb81ab1n18x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mlsn280ab1d09x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqsnbf1ab1n12x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqsnna3ab1n06x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mzdcf33ub1n32x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mzdcf33ub1n04x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqsnbf1ab1n18x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqsnin1ab1n12x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqsnca4ab1n06x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqsnno3ab1n06x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqsnin1ab1n18x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqsnfs4ab1d06x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mydp122ub1n00x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqsnls3ab1d06x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mzdcf33ub1n08x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mzdcf33ub1n16x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqbnna2bc1d20x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqbnno2bc1d20x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqbnbf2bc1d30x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mqsnco4ab1n06x5.sp
*   End of subcircuit definition.

* /nfs/site/proj/mpg/proc/projects/db_root/i78lncip/i0m_cltr_i78lncip/std/lncstd_i0m_8.0/i0m_cltr/sp/i0mcrb0bfab1n18x5.sp
*   End of subcircuit definition.
