*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Jan 31 11:43:10 2024
*  Design library name: flat_schematic_lib
*  Design cell name: i0mzdcf33ub1n32x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mzdcf33ub1n32x5
*  View name: schematic
.SUBCKT i0mzdcf33ub1n32x5 vcc vssx
*  INOUT: vcc vssx
*  INPUT:
*  OUTPUT:
Mqpdecap1.mp3 vcc vssx vcc vcc phpalvt W=3 L=14e-9 M=31 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Jan 31 11:43:18 2024
*  Design library name: flat_schematic_lib
*  Design cell name: i0mzdcf33ub1n16x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mzdcf33ub1n16x5
*  View name: schematic
.SUBCKT i0mzdcf33ub1n16x5 vcc vssx
*  INOUT: vcc vssx
*  INPUT:
*  OUTPUT:
Mqpdecap1.mp3 vcc vssx vcc vcc phpalvt W=3 L=14e-9 M=15 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Jan 31 11:43:13 2024
*  Design library name: flat_schematic_lib
*  Design cell name: i0mzdcf33ub1n08x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mzdcf33ub1n08x5
*  View name: schematic
.SUBCKT i0mzdcf33ub1n08x5 vcc vssx
*  INOUT: vcc vssx
*  INPUT:
*  OUTPUT:
Mqpdecap1.mp3 vcc vssx vcc vcc phpalvt W=3 L=14e-9 M=7 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct 18 00:33:36 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mzdcf33ub1n04x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mzdcf33ub1n04x5
*  View name: schematic
.SUBCKT i0mzdcf33ub1n04x5 vcc vssx
*  INOUT: vcc vssx
*  INPUT:
*  OUTPUT:
Mqpdecap1.mp3 vcc vssx vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct 25 02:19:03 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mydp122uc1n00x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mydp122uc1n00x5
*  View name: schematic
.SUBCKT i0mydp122uc1n00x5 dpd1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: dpd1
*  OUTPUT:
Mqngnac1.mn2 dpd1 vssx vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct 25 02:19:03 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mydp122ub1n00x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mydp122ub1n00x5
*  View name: schematic
.SUBCKT i0mydp122ub1n00x5 dpd1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: dpd1
*  OUTPUT:
Mqngnac1.mn2 dpd1 vssx vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:42:04 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0morn002ac1n09x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0morn002ac1n09x5
*  View name: schematic
.SUBCKT i0morn002ac1n09x5 a b o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o
Mg1.qpb.mp3 g1.n1 b vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp3 n1 a g1.n1 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn3 n1 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qnb.mn3 n1 b vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:23:16 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0morn002ac1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0morn002ac1n02x5
*  View name: schematic
.SUBCKT i0morn002ac1n02x5 a b o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o
Mg1.qpb.mp2 g1.n1 b vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp2 n1 a g1.n1 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 n1 a vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qnb.mn2 n1 b vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn2 o n1 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o n1 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:51:18 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor042ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor042ac1n03x5
*  View name: schematic
.SUBCKT i0mnor042ac1n03x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qpb.mp3 g0.n1 b vcc vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a g0.n1 vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 o1 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 o1 b vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 12:22:56 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor003ac1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor003ac1n06x5
*  View name: schematic
.SUBCKT i0mnor003ac1n06x5 a b c o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c
*  OUTPUT: o1
Mg0.qpc.mp3 g0.n1 c vcc vcc phpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp3 g0.n2 b g0.n1 vcc phpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a g0.n2 vcc phpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 o1 a vssx vssx nhpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 o1 b vssx vssx nhpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn2 o1 c vssx vssx nhpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 12:21:21 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor003ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor003ac1n03x5
*  View name: schematic
.SUBCKT i0mnor003ac1n03x5 a b c o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c
*  OUTPUT: o1
Mg0.qpc.mp2 g0.n1 c vcc vcc phpasvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 g0.n2 b g0.n1 vcc phpasvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a g0.n2 vcc phpasvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 o1 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 o1 b vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn3 o1 c vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:53:54 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor003ab1n12x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor003ab1n12x5
*  View name: schematic
.SUBCKT i0mnor003ab1n12x5 a b c o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c
*  OUTPUT: o1
Mg0.qpc.mp3 g0.n1 c vcc vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp3 g0.n2 b g0.n1 vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a g0.n2 vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 o1 a vssx vssx nhpalvt W=2 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 o1 b vssx vssx nhpalvt W=2 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn2 o1 c vssx vssx nhpalvt W=2 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:45:37 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor003ab1n10x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor003ab1n10x5
*  View name: schematic
.SUBCKT i0mnor003ab1n10x5 a b c o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c
*  OUTPUT: o1
Mg0.qpc.mp3 g0.n1 c vcc vcc phpalvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp3 g0.n2 b g0.n1 vcc phpalvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a g0.n2 vcc phpalvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 o1 a vssx vssx nhpalvt W=2 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 o1 b vssx vssx nhpalvt W=2 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn2 o1 c vssx vssx nhpalvt W=2 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 12:21:18 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor003ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor003ab1n03x5
*  View name: schematic
.SUBCKT i0mnor003ab1n03x5 a b c o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c
*  OUTPUT: o1
Mg0.qpc.mp2 g0.n1 c vcc vcc phpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 g0.n2 b g0.n1 vcc phpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a g0.n2 vcc phpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 o1 b vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn3 o1 c vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:51:37 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor002ac1n16x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor002ac1n16x5
*  View name: schematic
.SUBCKT i0mnor002ac1n16x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qpb.mp3 g0.n1 b vcc vcc phpasvt W=3 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a g0.n1 vcc phpasvt W=3 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 o1 a vssx vssx nhpasvt W=2 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 o1 b vssx vssx nhpasvt W=2 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 20:06:42 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor002ac1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor002ac1n06x5
*  View name: schematic
.SUBCKT i0mnor002ac1n06x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qpb.mp3 g0.n1 b vcc vcc phpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a g0.n1 vcc phpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 o1 a vssx vssx nhpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 o1 b vssx vssx nhpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:38:11 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor002ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor002ac1n03x5
*  View name: schematic
.SUBCKT i0mnor002ac1n03x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qpb.mp2 g0.n1 b vcc vcc phpasvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a g0.n1 vcc phpasvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 o1 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 o1 b vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:55:25 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor002ac1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor002ac1n02x5
*  View name: schematic
.SUBCKT i0mnor002ac1n02x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qpb.mp3 g0.n1 b vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a g0.n1 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 o1 a vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 o1 b vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 13:54:27 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor002ab1n12x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor002ab1n12x5
*  View name: schematic
.SUBCKT i0mnor002ab1n12x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qpb.mp3 g0.n1 b vcc vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a g0.n1 vcc phpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 o1 a vssx vssx nhpalvt W=2 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 o1 b vssx vssx nhpalvt W=2 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 20:03:05 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor002ab1n10x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor002ab1n10x5
*  View name: schematic
.SUBCKT i0mnor002ab1n10x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qpb.mp3 g0.n1 b vcc vcc phpalvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a g0.n1 vcc phpalvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 o1 a vssx vssx nhpalvt W=2 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 o1 b vssx vssx nhpalvt W=2 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 20:06:52 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor002ab1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor002ab1n06x5
*  View name: schematic
.SUBCKT i0mnor002ab1n06x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qpb.mp3 g0.n1 b vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a g0.n1 vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 o1 a vssx vssx nhpalvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 o1 b vssx vssx nhpalvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:37:57 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnor002ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnor002ab1n03x5
*  View name: schematic
.SUBCKT i0mnor002ab1n03x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qpb.mp2 g0.n1 b vcc vcc phpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a g0.n1 vcc phpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 o1 b vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 17:22:41 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand04ac1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand04ac1n06x5
*  View name: schematic
.SUBCKT i0mnand04ac1n06x5 a b c d o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c d
*  OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b g0.n2 vssx nhpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn3 g0.n2 c g0.n3 vssx nhpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnd.mn3 g0.n3 d vssx vssx nhpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpc.mp2 o1 c vcc vcc phpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpd.mp2 o1 d vcc vcc phpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 18:54:34 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand03ac1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand03ac1n06x5
*  View name: schematic
.SUBCKT i0mnand03ac1n06x5 a b c o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c
*  OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b g0.n2 vssx nhpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn3 g0.n2 c vssx vssx nhpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpc.mp2 o1 c vcc vcc phpasvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 12:45:00 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand03ac1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand03ac1n02x5
*  View name: schematic
.SUBCKT i0mnand03ac1n02x5 a b c o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c
*  OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b g0.n2 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn3 g0.n2 c vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpc.mp2 o1 c vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 18:54:55 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand03ab1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand03ab1n06x5
*  View name: schematic
.SUBCKT i0mnand03ab1n06x5 a b c o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c
*  OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b g0.n2 vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn3 g0.n2 c vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpalvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpalvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpc.mp2 o1 c vcc vcc phpalvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:53:48 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand03ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand03ab1n03x5
*  View name: schematic
.SUBCKT i0mnand03ab1n03x5 a b c o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c
*  OUTPUT: o1
Mg0.qna.mn2 o1 a g0.n1 vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 g0.n1 b g0.n2 vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn2 g0.n2 c vssx vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp3 o1 b vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpc.mp3 o1 c vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 13:16:37 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand02ac1n16x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand02ac1n16x5
*  View name: schematic
.SUBCKT i0mnand02ac1n16x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpasvt W=3 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b vssx vssx nhpasvt W=3 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpasvt W=2 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpasvt W=2 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:47:45 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand02ac1n10x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand02ac1n10x5
*  View name: schematic
.SUBCKT i0mnand02ac1n10x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpasvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b vssx vssx nhpasvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpasvt W=2 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpasvt W=2 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 12:22:35 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand02ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand02ac1n03x5
*  View name: schematic
.SUBCKT i0mnand02ac1n03x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qna.mn2 o1 a g0.n1 vssx nhpasvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 g0.n1 b vssx vssx nhpasvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp3 o1 b vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:55:22 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand02ac1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand02ac1n02x5
*  View name: schematic
.SUBCKT i0mnand02ac1n02x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 18:58:40 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand02ab1n12x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand02ab1n12x5
*  View name: schematic
.SUBCKT i0mnand02ab1n12x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b vssx vssx nhpalvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpalvt W=2 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpalvt W=2 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:47:20 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand02ab1n10x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand02ab1n10x5
*  View name: schematic
.SUBCKT i0mnand02ab1n10x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpalvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b vssx vssx nhpalvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpalvt W=2 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpalvt W=2 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 13:42:59 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand02ab1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand02ab1n06x5
*  View name: schematic
.SUBCKT i0mnand02ab1n06x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpalvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpalvt W=2 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 12:22:33 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand02ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand02ab1n03x5
*  View name: schematic
.SUBCKT i0mnand02ab1n03x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qna.mn2 o1 a g0.n1 vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn2 g0.n1 b vssx vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp3 o1 b vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:55:24 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mnand02ab1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mnand02ab1n02x5
*  View name: schematic
.SUBCKT i0mnand02ab1n02x5 a b o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o1
Mg0.qna.mn3 o1 a g0.n1 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 b vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 o1 a vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp2 o1 b vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:38:11 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mlun090ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mlun090ac1n03x5
*  View name: schematic
.SUBCKT i0mlun090ac1n03x5 clkb d ob vcc vssx
*  INOUT: vcc vssx
*  INPUT: clkb d
*  OUTPUT: ob
Mg3lp1.qnck.mn2 ob clkb g3lp1.n2 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnd.mn2 g3lp1.n2 nk2 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpckb.mp2 ob nc1 g3lp1.n1 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpd.mp2 g3lp1.n1 nk2 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qpsb.mp3 ob clkb n3 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qns.mn3 ob nc1 n3 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp2 nc1 clkb vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 nc1 clkb vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qpa.mp3 n3 d vcc vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg2.qna.mn3 n3 d vssx vssx nhpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg2lp1.qpa.mp2 nk2 ob vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qna.mn2 nk2 ob vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:53:13 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mlun090ac1d06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mlun090ac1d06x5
*  View name: schematic
.SUBCKT i0mlun090ac1d06x5 clkb d ob vcc vssx
*  INOUT: vcc vssx
*  INPUT: clkb d
*  OUTPUT: ob
Mg3lp1.qnck.mn3 ob clkb g3lp1.n2 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnd.mn3 g3lp1.n2 nk2 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpckb.mp3 ob nc1 g3lp1.n1 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpd.mp3 g3lp1.n1 nk2 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qpsb.mp3 ob clkb n3 vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg1lp1.qns.mn3 ob nc1 n3 vssx nhpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp2 nc1 clkb vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 nc1 clkb vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qpa.mp3 n3 d vcc vcc phpasvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg2.qna.mn3 n3 d vssx vssx nhpasvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg2lp1.qpa.mp2 nk2 ob vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qna.mn2 nk2 ob vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:53:02 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mlun090ab1d06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mlun090ab1d06x5
*  View name: schematic
.SUBCKT i0mlun090ab1d06x5 clkb d ob vcc vssx
*  INOUT: vcc vssx
*  INPUT: clkb d
*  OUTPUT: ob
Mg3lp1.qnck.mn3 ob clkb g3lp1.n2 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnd.mn3 g3lp1.n2 nk2 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpckb.mp3 ob nc1 g3lp1.n1 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpd.mp3 g3lp1.n1 nk2 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qpsb.mp3 ob clkb n3 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg1lp1.qns.mn3 ob nc1 n3 vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp2 nc1 clkb vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 nc1 clkb vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qpa.mp3 n3 d vcc vcc phpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg2.qna.mn3 n3 d vssx vssx nhpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg2lp1.qpa.mp2 nk2 ob vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qna.mn2 nk2 ob vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:56:01 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mlsnan3ab1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mlsnan3ab1n06x5
*  View name: schematic
.SUBCKT i0mlsnan3ab1n06x5 clk da db dc o vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk da db dc
*  OUTPUT: o
Mg101.qna.mn3 o nk1 vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o nk1 vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg2.qna.mn3 n3 da g2.n1 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qnb.mn3 g2.n1 db g2.n2 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qnc.mn3 g2.n2 dc vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qpc.mp3 n3 dc vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qpb.mp3 n3 db vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qpa.mp3 n3 da vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp2 nc1 clk vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 nc1 clk vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qpa.mp2 nk2 nk1 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qna.mn2 nk2 nk1 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qpsb.mp3 nk1 nc1 n3 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qns.mn3 nk1 clk n3 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnck.mn2 nk1 nc1 g3lp1.n2 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnd.mn2 g3lp1.n2 nk2 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpckb.mp2 nk1 clk g3lp1.n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpd.mp2 g3lp1.n1 nk2 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:10:17 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mlsn080ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mlsn080ac1n03x5
*  View name: schematic
.SUBCKT i0mlsn080ac1n03x5 clkb d o vcc vssx
*  INOUT: vcc vssx
*  INPUT: clkb d
*  OUTPUT: o
Mg1.qpa.mp2 nc1 clkb vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 nc1 clkb vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qpa.mp2 n3 d vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qna.mn2 n3 d vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qpa.mp2 nk2 nk1 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qna.mn2 nk2 nk1 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qpsb.mp2 nk1 clkb n3 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qns.mn2 nk1 nc1 n3 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o nk1 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o nk1 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnck.mn2 nk1 clkb g3lp1.n2 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnd.mn2 g3lp1.n2 nk2 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpckb.mp2 nk1 nc1 g3lp1.n1 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpd.mp2 g3lp1.n1 nk2 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:06:56 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mlsn080ac1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mlsn080ac1n02x5
*  View name: schematic
.SUBCKT i0mlsn080ac1n02x5 clkb d o vcc vssx
*  INOUT: vcc vssx
*  INPUT: clkb d
*  OUTPUT: o
Mg1.qpa.mp2 nc1 clkb vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 nc1 clkb vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qpa.mp2 n3 d vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qna.mn2 n3 d vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qpa.mp2 nk2 nk1 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qna.mn2 nk2 nk1 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qpsb.mp2 nk1 clkb n3 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qns.mn2 nk1 nc1 n3 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn2 o nk1 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o nk1 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnck.mn2 nk1 clkb g3lp1.n2 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnd.mn2 g3lp1.n2 nk2 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpckb.mp2 nk1 nc1 g3lp1.n1 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpd.mp2 g3lp1.n1 nk2 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:10:18 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mlsn000ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mlsn000ac1n03x5
*  View name: schematic
.SUBCKT i0mlsn000ac1n03x5 clk d o vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk d
*  OUTPUT: o
Mg2.qpa.mp2 n3 d vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2.qna.mn2 n3 d vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp2 nc1 clk vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 nc1 clk vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qpa.mp2 nk2 nk1 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg2lp1.qna.mn2 nk2 nk1 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qpsb.mp2 nk1 nc1 n3 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1lp1.qns.mn2 nk1 clk n3 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o nk1 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o nk1 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnck.mn2 nk1 nc1 g3lp1.n2 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qnd.mn2 g3lp1.n2 nk2 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpckb.mp2 nk1 clk g3lp1.n1 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg3lp1.qpd.mp2 g3lp1.n1 nk2 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:09:10 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ac1n36x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ac1n36x5
*  View name: schematic
.SUBCKT i0minv000ac1n36x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpasvt W=3 L=14e-9 M=12 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpasvt W=3 L=14e-9 M=12 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:11:00 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ac1n24x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ac1n24x5
*  View name: schematic
.SUBCKT i0minv000ac1n24x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpasvt W=3 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpasvt W=3 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:22:51 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ac1n15x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ac1n15x5
*  View name: schematic
.SUBCKT i0minv000ac1n15x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpasvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpasvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:15:30 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ac1n12x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ac1n12x5
*  View name: schematic
.SUBCKT i0minv000ac1n12x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpasvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpasvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:22:40 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ac1n09x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ac1n09x5
*  View name: schematic
.SUBCKT i0minv000ac1n09x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Feb  6 12:10:14 2024
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ac1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ac1n06x5
*  View name: schematic
.SUBCKT i0minv000ac1n06x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  5 13:55:26 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ac1n03x5
*  View name: schematic
.SUBCKT i0minv000ac1n03x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  5 14:11:20 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ac1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ac1n02x5
*  View name: schematic
.SUBCKT i0minv000ac1n02x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn2 o1 a vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o1 a vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:09:21 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ab1n36x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ab1n36x5
*  View name: schematic
.SUBCKT i0minv000ab1n36x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=12 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=12 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:07:46 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ab1n30x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ab1n30x5
*  View name: schematic
.SUBCKT i0minv000ab1n30x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:23:07 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ab1n15x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ab1n15x5
*  View name: schematic
.SUBCKT i0minv000ab1n15x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:15:55 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ab1n12x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ab1n12x5
*  View name: schematic
.SUBCKT i0minv000ab1n12x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:22:42 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ab1n09x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ab1n09x5
*  View name: schematic
.SUBCKT i0minv000ab1n09x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Feb  6 12:09:59 2024
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ab1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ab1n06x5
*  View name: schematic
.SUBCKT i0minv000ab1n06x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  5 13:55:32 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ab1n03x5
*  View name: schematic
.SUBCKT i0minv000ab1n03x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  5 14:11:19 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ab1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ab1n02x5
*  View name: schematic
.SUBCKT i0minv000ab1n02x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn2 o1 a vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o1 a vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:53:08 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0minv000ab1d42x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0minv000ab1d42x5
*  View name: schematic
.SUBCKT i0minv000ab1d42x5 a o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o1
Mg101.qna.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=14 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o1 a vcc vcc phpalvt W=3 L=14e-9 M=14 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 18:58:48 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mfhn000ac1d02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mfhn000ac1d02x5
*  View name: schematic
.SUBCKT i0mfhn000ac1d02x5 clk d o vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk d
*  OUTPUT: o
Mgclkdd.qpa.mp2 nc2 nc1 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgclkdd.qna.mn2 nc2 nc1 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgin1.qpa.mp2 n1 d vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgin1.qna.mn2 n1 d vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgclkn.qpa.mp2 nc1 clk vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgclkn.qna.mn2 nc1 clk vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgclkn2.qpa.mp2 nc3 nc2 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgclkn2.qna.mn2 nc3 nc2 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd2n.qpa.mp2 nk6 nk5 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd2n.qna.mn2 nk6 nk5 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg902.qpa.mp2 n2 n1 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg902.qna.mn2 n2 n1 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd1n.qpa.mp2 nk4 nk3 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd1n.qna.mn2 nk4 nk3 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn2 o nk5 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o nk5 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgtd2.qpsb.mp2 nk5 nc1 nk4 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgtd2.qns.mn2 nk5 clk nk4 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgtd1.qpsb.mp2 nk3 nc2 n2 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgtd1.qns.mn2 nk3 nc3 n2 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd1.qnck.mn2 nk3 nc2 gd1.n2 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd1.qnd.mn2 gd1.n2 nk4 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd1.qpckb.mp2 nk3 nc3 gd1.n1 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd1.qpd.mp2 gd1.n1 nk4 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd2.qnck.mn2 nk5 nc1 gd2.n2 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd2.qnd.mn2 gd2.n2 nk6 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd2.qpckb.mp2 nk5 clk gd2.n1 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mgd2.qpd.mp2 gd2.n1 nk6 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:48:51 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mclbno3ab1n04x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mclbno3ab1n04x5
*  View name: schematic
.SUBCKT i0mclbno3ab1n04x5 clk clkout enb1 enb2 vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk enb1 enb2
*  OUTPUT: clkout
Mg0.qpc.mp3 g0.n1 enb2 vcc vcc phpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp3 g0.n2 enb1 g0.n1 vcc phpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 clkout clk g0.n2 vcc phpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 clkout clk vssx vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 clkout enb1 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn3 clkout enb2 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct 11 23:04:44 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mclbno2ab1n12x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mclbno2ab1n12x5
*  View name: schematic
.SUBCKT i0mclbno2ab1n12x5 clk clkout enb vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk enb
*  OUTPUT: clkout
Mg0.qpb.mp3 g0.n1 enb vcc vcc phpalvt W=3 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 clkout clk g0.n1 vcc phpalvt W=3 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 clkout clk vssx vssx nhpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 clkout enb vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:49:13 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mclbno2ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mclbno2ab1n03x5
*  View name: schematic
.SUBCKT i0mclbno2ab1n03x5 clk clkout enb vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk enb
*  OUTPUT: clkout
Mg0.qpb.mp3 g0.n1 enb vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 clkout clk g0.n1 vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 clkout clk vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 clkout enb vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 12:38:20 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mclbna3ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mclbna3ab1n03x5
*  View name: schematic
.SUBCKT i0mclbna3ab1n03x5 clk clkout en1 en2 vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk en1 en2
*  OUTPUT: clkout
Mg0.qna.mn3 clkout clk g0.n1 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 en1 g0.n2 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnc.mn3 g0.n2 en2 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 clkout clk vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp3 clkout en1 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpc.mp3 clkout en2 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:55:28 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mclbna2ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mclbna2ab1n03x5
*  View name: schematic
.SUBCKT i0mclbna2ab1n03x5 clk clkout en vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk en
*  OUTPUT: clkout
Mg0.qna.mn3 clkout clk g0.n1 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qnb.mn3 g0.n1 en vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 clkout clk vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpb.mp3 clkout en vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:15:34 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mcinv00ab1n36x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mcinv00ab1n36x5
*  View name: schematic
.SUBCKT i0mcinv00ab1n36x5 clk clkout vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk
*  OUTPUT: clkout
Mg101.qpa.mp3 clkout clk vcc vcc phpalvt W=3 L=14e-9 M=15 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 clkout clk vssx vssx nhpalvt W=3 L=14e-9 M=12 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:21:13 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mcinv00ab1n24x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mcinv00ab1n24x5
*  View name: schematic
.SUBCKT i0mcinv00ab1n24x5 clk clkout vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk
*  OUTPUT: clkout
Mg101.qpa.mp3 clkout clk vcc vcc phpalvt W=3 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 clkout clk vssx vssx nhpalvt W=3 L=14e-9 M=8 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:18:44 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mcinv00ab1n12x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mcinv00ab1n12x5
*  View name: schematic
.SUBCKT i0mcinv00ab1n12x5 clk clkout vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk
*  OUTPUT: clkout
Mg101.qpa.mp3 clkout clk vcc vcc phpalvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 clkout clk vssx vssx nhpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 20:40:02 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mcinv00ab1n04x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mcinv00ab1n04x5
*  View name: schematic
.SUBCKT i0mcinv00ab1n04x5 clk clkout vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk
*  OUTPUT: clkout
Mg101.qpa.mp3 clkout clk vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn2 clkout clk vssx vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:11:56 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mcbf000ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mcbf000ab1n03x5
*  View name: schematic
.SUBCKT i0mcbf000ab1n03x5 clk clkout vcc vssx
*  INOUT: vcc vssx
*  INPUT: clk
*  OUTPUT: clkout
Mg0.qpa.mp2 nc1 clk vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 nc1 clk vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qp0.mp3 clkout nc1 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qn0.mn3 clkout nc1 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:18:56 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ac1n18x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ac1n18x5
*  View name: schematic
.SUBCKT i0mbfn000ac1n18x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp3 n1 a vcc vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n1 a vssx vssx nhpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpasvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpasvt W=3 L=14e-9 M=6 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Feb  6 12:26:46 2024
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ac1n12x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ac1n12x5
*  View name: schematic
.SUBCKT i0mbfn000ac1n12x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp3 n1 a vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n1 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpasvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpasvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:20:06 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ac1n09x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ac1n09x5
*  View name: schematic
.SUBCKT i0mbfn000ac1n09x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp3 n1 a vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n1 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpasvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:23:04 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ac1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ac1n06x5
*  View name: schematic
.SUBCKT i0mbfn000ac1n06x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp2 n1 a vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 n1 a vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:20:05 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ac1n03x5
*  View name: schematic
.SUBCKT i0mbfn000ac1n03x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp2 n1 a vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 n1 a vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  5 14:13:02 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ac1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ac1n02x5
*  View name: schematic
.SUBCKT i0mbfn000ac1n02x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp2 n1 a vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 n1 a vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o n1 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn2 o n1 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:53:06 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ac1d42x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ac1d42x5
*  View name: schematic
.SUBCKT i0mbfn000ac1d42x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp3 n1 a vcc vcc phpasvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n1 a vssx vssx nhpasvt W=3 L=14e-9 M=5 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpasvt W=3 L=14e-9 M=14 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpasvt W=3 L=14e-9 M=14 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:42:28 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ab1n36x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ab1n36x5
*  View name: schematic
.SUBCKT i0mbfn000ab1n36x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp3 n1 a vcc vcc phpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n1 a vssx vssx nhpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpalvt W=3 L=14e-9 M=12 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpalvt W=3 L=14e-9 M=12 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:03:04 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ab1n30x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ab1n30x5
*  View name: schematic
.SUBCKT i0mbfn000ab1n30x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp3 n1 a vcc vcc phpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n1 a vssx vssx nhpalvt W=3 L=14e-9 M=4 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpalvt W=3 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpalvt W=3 L=14e-9 M=10 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:23:03 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ab1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ab1n06x5
*  View name: schematic
.SUBCKT i0mbfn000ab1n06x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp2 n1 a vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 n1 a vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:19:45 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ab1n03x5
*  View name: schematic
.SUBCKT i0mbfn000ab1n03x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp2 n1 a vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 n1 a vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n1 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  5 14:13:01 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfn000ab1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfn000ab1n02x5
*  View name: schematic
.SUBCKT i0mbfn000ab1n02x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp2 n1 a vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 n1 a vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o n1 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn2 o n1 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:56:20 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm807ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm807ac1n03x5
*  View name: schematic
.SUBCKT i0mbfm807ac1n03x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn3 o n0 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n0 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp9.mp3 n9 n12 n10 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp8.mp3 n10 n12 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp11.mp3 n12 n15 n13 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp10.mp3 n13 n15 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp3 n1 n3 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp3.mp3 n0 n3 n1 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp5.mp3 n3 n6 n4 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp4.mp3 n4 n6 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp7.mp3 n6 n9 n7 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp15.mp3 n21 a vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp6.mp3 n7 n9 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp14.mp3 n15 n20 n17 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp16.mp3 n20 a n21 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp13.mp3 n17 n20 n16 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp12.mp3 n16 n20 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn9.mn3 n11 n12 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn8.mn3 n9 n12 n11 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn11.mn3 n14 n15 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn10.mn3 n12 n15 n14 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn3 n0 n3 n2 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn3.mn3 n2 n3 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn5.mn3 n5 n6 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn4.mn3 n3 n6 n5 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn15.mn3 n20 a n22 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn12.mn3 n15 n20 n18 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn13.mn3 n18 n20 n19 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn16.mn3 n22 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn14.mn3 n19 n20 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn7.mn3 n8 n9 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn6.mn3 n6 n9 n8 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:56:48 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm807ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm807ab1n03x5
*  View name: schematic
.SUBCKT i0mbfm807ab1n03x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn3 o n0 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n0 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp9.mp3 n9 n12 n10 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp8.mp3 n10 n12 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp11.mp3 n12 n15 n13 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp10.mp3 n13 n15 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp3 n1 n3 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp3.mp3 n0 n3 n1 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp5.mp3 n3 n6 n4 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp4.mp3 n4 n6 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp7.mp3 n6 n9 n7 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp15.mp3 n21 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp6.mp3 n7 n9 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp14.mp3 n15 n20 n17 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp16.mp3 n20 a n21 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp13.mp3 n17 n20 n16 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp12.mp3 n16 n20 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn9.mn3 n11 n12 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn8.mn3 n9 n12 n11 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn11.mn3 n14 n15 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn10.mn3 n12 n15 n14 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn3 n0 n3 n2 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn3.mn3 n2 n3 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn5.mn3 n5 n6 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn4.mn3 n3 n6 n5 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn15.mn3 n20 a n22 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn12.mn3 n15 n20 n18 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn13.mn3 n18 n20 n19 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn16.mn3 n22 a vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn14.mn3 n19 n20 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn7.mn3 n8 n9 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn6.mn3 n6 n9 n8 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:13:18 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm605ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm605ac1n03x5
*  View name: schematic
.SUBCKT i0mbfm605ac1n03x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn3 o n0 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n0 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp3 n1 n3 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp3.mp3 n0 n3 n1 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp5.mp3 n3 n6 n4 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp4.mp3 n4 n6 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp7.mp3 n6 n9 n7 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp11.mp3 n15 a vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp6.mp3 n7 n9 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp10.mp3 n9 n14 n11 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp12.mp3 n14 a n15 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp9.mp3 n11 n14 n10 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp8.mp3 n10 n14 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn3 n0 n3 n2 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn3.mn3 n2 n3 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn5.mn3 n5 n6 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn4.mn3 n3 n6 n5 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn11.mn3 n14 a n16 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn8.mn3 n9 n14 n12 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn9.mn3 n12 n14 n13 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn12.mn3 n16 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn10.mn3 n13 n14 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn7.mn3 n8 n9 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn6.mn3 n6 n9 n8 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 20:05:20 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm604ac1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm604ac1n02x5
*  View name: schematic
.SUBCKT i0mbfm604ac1n02x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn2 o n4 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o n4 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 n0 a vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 n0 a vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn8.mn2 n108 n3 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn7.mn2 n4 n3 n108 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn5.mn2 n3 n2 n106 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn6.mn2 n106 n2 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn4.mn2 n104 n1 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn3.mn2 n2 n1 n104 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn2 n1 n0 n102 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn2 n102 n0 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp7.mp2 n4 n3 n107 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp8.mp2 n107 n3 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp6.mp2 n105 n2 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp5.mp2 n3 n2 n105 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp3.mp2 n2 n1 n103 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp2 n101 n0 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp2 n1 n0 n101 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp4.mp2 n103 n1 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:49:09 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm604ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm604ab1n03x5
*  View name: schematic
.SUBCKT i0mbfm604ab1n03x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg0.qpa.mp3 n0 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n0 a vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qna.mn3 o n4 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n4 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn8.mn3 n108 n3 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn7.mn3 n4 n3 n108 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn5.mn3 n3 n2 n106 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn6.mn3 n106 n2 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn4.mn3 n104 n1 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn3.mn3 n2 n1 n104 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn3 n1 n0 n102 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn3 n102 n0 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp7.mp3 n4 n3 n107 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp8.mp3 n107 n3 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp6.mp3 n105 n2 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp5.mp3 n3 n2 n105 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp3.mp3 n2 n1 n103 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp3 n101 n0 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 n1 n0 n101 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp4.mp3 n103 n1 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:52:12 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm402ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm402ac1n03x5
*  View name: schematic
.SUBCKT i0mbfm402ac1n03x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn3 o n2 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n2 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp3.mp3 n2 n1 n103 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp3 n101 n0 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 n1 n0 n101 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp4.mp3 n103 n1 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn4.mn3 n104 n1 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn3.mn3 n2 n1 n104 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn3 n1 n0 n102 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn3 n102 n0 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 n0 a vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n0 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 12:38:06 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm402ac1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm402ac1n02x5
*  View name: schematic
.SUBCKT i0mbfm402ac1n02x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn2 o n2 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o n2 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp3.mp2 n2 n1 n103 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp2 n101 n0 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp2 n1 n0 n101 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp4.mp2 n103 n1 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn4.mn2 n104 n1 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn3.mn2 n2 n1 n104 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn2 n1 n0 n102 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn2 n102 n0 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp2 n0 a vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn2 n0 a vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:52:23 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm402ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm402ab1n03x5
*  View name: schematic
.SUBCKT i0mbfm402ab1n03x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn3 o n2 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n2 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp3.mp3 n2 n1 n103 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp3 n101 n0 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 n1 n0 n101 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp4.mp3 n103 n1 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn4.mn3 n104 n1 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn3.mn3 n2 n1 n104 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn3 n1 n0 n102 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn3 n102 n0 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qpa.mp3 n0 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg0.qna.mn3 n0 a vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 13:06:46 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm202ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm202ab1n03x5
*  View name: schematic
.SUBCKT i0mbfm202ab1n03x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mqp3.mp3 o n1 n103 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp3 n101 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 n1 a n101 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp4.mp3 n103 n1 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn4.mn3 n104 n1 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn3.mn3 o n1 n104 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn3 n1 a n102 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn3 n102 a vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 20:52:50 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm201ac1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm201ac1n06x5
*  View name: schematic
.SUBCKT i0mbfm201ac1n06x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn3 o n2 vssx vssx nhpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n2 vcc vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqn2.mn3 n0 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn3 n2 a n0 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp3 n1 a vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 n2 a n1 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:16:56 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm201ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm201ac1n03x5
*  View name: schematic
.SUBCKT i0mbfm201ac1n03x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn3 o n2 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n2 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn3 n0 a vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn3 n2 a n0 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp3 n1 a vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 n2 a n1 vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 20:55:56 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm201ac1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm201ac1n02x5
*  View name: schematic
.SUBCKT i0mbfm201ac1n02x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn2 o n2 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o n2 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn2 n0 a vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn2 n2 a n0 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp2 n1 a vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp2 n2 a n1 vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 20:52:48 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm201ab1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm201ab1n06x5
*  View name: schematic
.SUBCKT i0mbfm201ab1n06x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn3 o n2 vssx vssx nhpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n2 vcc vcc phpalvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqn2.mn3 n0 a vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn3 n2 a n0 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp3 n1 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 n2 a n1 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  6 19:50:10 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm201ab1n04x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm201ab1n04x5
*  View name: schematic
.SUBCKT i0mbfm201ab1n04x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn2 o n2 vssx vssx nhpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o n2 vcc vcc phpalvt W=2 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqn2.mn2 n0 a vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn2 n2 a n0 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp2 n1 a vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp2 n2 a n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:17:08 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm201ab1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm201ab1n03x5
*  View name: schematic
.SUBCKT i0mbfm201ab1n03x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn3 o n2 vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n2 vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn3 n0 a vssx vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn3 n2 a n0 vssx nhpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp3 n1 a vcc vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp3 n2 a n1 vcc phpalvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 20:56:01 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mbfm201ab1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mbfm201ab1n02x5
*  View name: schematic
.SUBCKT i0mbfm201ab1n02x5 a o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a
*  OUTPUT: o
Mg101.qna.mn2 o n2 vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o n2 vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn2.mn2 n0 a vssx vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqn1.mn2 n2 a n0 vssx nhpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp2.mp2 n1 a vcc vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mqp1.mp2 n2 a n1 vcc phpalvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:15:25 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0maoi022ac1n06x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0maoi022ac1n06x5
*  View name: schematic
.SUBCKT i0maoi022ac1n06x5 a b c d o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c d
*  OUTPUT: o1
Mqnd1.mn3 n3 d vssx vssx nhpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqnb1.mn3 n2 b vssx vssx nhpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqna1.mn3 o1 a n2 vssx nhpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqnc1.mn3 o1 c n3 vssx nhpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpa1.mp3 o1 a n1 vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpc1.mp3 n1 c vcc vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpd1.mp3 n1 d vcc vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
Mqpb1.mp3 o1 b n1 vcc phpasvt W=3 L=14e-9 M=2 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:23:06 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0maoi012ab1n09x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0maoi012ab1n09x5
*  View name: schematic
.SUBCKT i0maoi012ab1n09x5 a b c o1 vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b c
*  OUTPUT: o1
Mqnc1.mn3 n2 c vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqnb1.mn3 o1 b n2 vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqna1.mn3 o1 a vssx vssx nhpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqpc1.mp3 n1 c vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqpb1.mp3 n1 b vcc vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
Mqpa1.mp3 o1 a n1 vcc phpalvt W=3 L=14e-9 M=3 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:17:13 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mand002ac1n03x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mand002ac1n03x5
*  View name: schematic
.SUBCKT i0mand002ac1n03x5 a b o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o
Mg101.qna.mn3 o n1 vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp3 o n1 vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn3 n1 a g1.n1 vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qnb.mn3 g1.n1 b vssx vssx nhpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp3 n1 a vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpb.mp3 n1 b vcc vcc phpasvt W=3 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

*  Netlist Is Generated By VMAC Netlister
*  VMAC version : 20.06.26_rc
*  Generated for: hspiceD
*  Generated on: Oct  4 21:23:24 2023
*  Design library name: flat_schematic_lib
*  Design cell name: i0mand002ac1n02x5
*  Design view name: schematic
*  Library name: flat_schematic_lib
*  Cell name: i0mand002ac1n02x5
*  View name: schematic
.SUBCKT i0mand002ac1n02x5 a b o vcc vssx
*  INOUT: vcc vssx
*  INPUT: a b
*  OUTPUT: o
Mg101.qna.mn2 o n1 vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg101.qpa.mp2 o n1 vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qna.mn2 n1 a g1.n1 vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qnb.mn2 g1.n1 b vssx vssx nhpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpa.mp2 n1 a vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
Mg1.qpb.mp2 n1 b vcc vcc phpasvt W=2 L=14e-9 M=1 NF=1 LVSEXACTMATCH=1
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issax2decredwleinv
* View Name:    schematic
************************************************************************
.SUBCKT issax2decredwleinv vcc vssx wle[1] wle[0] wlnn[1] wlnn[0]
*.PININFO vcc:I vssx:I wle[1]:I wle[0]:I wlnn[1]:O wlnn[0]:O
Mqnck0 wlnn[0] wle[0] vssx vssx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mqnck1 wlnn[1] wle[1] vssx vssx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mqpck1 wlnn[1] wle[1] vcc vcc phpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mqpck0 wlnn[0] wle[0] vcc vcc phpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issax2dec1
* View Name:    schematic
************************************************************************
.SUBCKT issax2dec1 c6save decvcc slpen vcc vssx wl wllvlnn[2] wllvlnn[1] wllvlnn[0]
+ wlnn
*.PININFO c6save:I decvcc:B slpen:I vcc:I vssx:I wl:O wllvlnn[2]:I wllvlnn[1]:I wllvlnn[0]:I wlnn:I
Mc6pdn wl c6save vssx vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Miwldrvn wl wlnn vssx vssx nhpalvt W=3.0 L=14n M=10 LVSEXACTMATCH=0
Mipwlud2 vssx wllvlnn[2] wl vcc phpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Miwldrvp wl wlnn decvcc vcc phpasvt W=3.0 L=14n M=15 LVSEXACTMATCH=0
Mipwlud01 vssx wllvlnn[0] wlud0net vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Miwldrvslp decvcc slpen vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mipwlud00 wlud0net wllvlnn[0] wl vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mipwlud1 vssx wllvlnn[1] wl vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issaxdecpre
* View Name:    schematic
************************************************************************
.SUBCKT issaxdecpre ab vcc vssx xpredechi xpredecmid
*.PININFO ab:O vcc:I vssx:I xpredechi:I xpredecmid:I
Mmn1 n0 xpredecmid n1 vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mmn0 n1 xpredechi vssx vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqn0 ab n0 vssx vssx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mmp1 n0 xpredecmid vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqp0 ab n0 vcc vcc phpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mmp0 n0 xpredechi vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issax2nand4
* View Name:    schematic
************************************************************************
.SUBCKT issax2nand4 ab shclk[3] shclk[2] shclk[1] shclk[0] vcc vssx wle[3] wle[2]
+ wle[1] wle[0] wlnn[3] wlnn[2] wlnn[1] wlnn[0]
*.PININFO ab:I shclk[3]:B shclk[2]:B shclk[1]:B shclk[0]:B vcc:I vssx:I wle[3]:I wle[2]:I wle[1]:I wle[0]:I wlnn[3]:O wlnn[2]:O wlnn[1]:O wlnn[0]:O
Mqnck2 shclk[2] wle[2] vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna2 wlnn[2] ab shclk[2] vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqna3 wlnn[3] ab shclk[3] vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqnck0 shclk[0] wle[0] vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnck1 shclk[1] wle[1] vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna0 wlnn[0] ab shclk[0] vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqnck3 shclk[3] wle[3] vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna1 wlnn[1] ab shclk[1] vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqpa2 wlnn[2] ab vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpck2 wlnn[2] wle[2] vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqpa1 wlnn[1] ab vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa3 wlnn[3] ab vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa0 wlnn[0] ab vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpck1 wlnn[1] wle[1] vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqpck3 wlnn[3] wle[3] vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqpck0 wlnn[0] wle[0] vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issax2dec256_4441547943835504324
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:2_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:2_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issax2dec256_4441547943835504324 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issax2dec256_12740764804200976283
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:6_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:6_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issax2dec256_12740764804200976283 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issax2dec256_7480748400340743147
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:5_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:5_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issax2dec256_7480748400340743147 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=5 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=5 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issax2dec256_13120004337063829235
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:5_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:5_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issax2dec256_13120004337063829235 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=5 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=5 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issax2dec256_9999192332891373312
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:4_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:4_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issax2dec256_9999192332891373312 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issax2dec256_13896219110017694169
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:3_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:3_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issax2dec256_13896219110017694169 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issax2dec256
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issax2decvccpdn
* View Name:    schematic
************************************************************************
.SUBCKT issax2decvccpdn c6savedec decvcc vssx
*.PININFO c6savedec:I decvcc:O vssx:I
Mc6decpdnt decvcc c6savedec vssx vssx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    xf_pcell_issaulsn080ac1d03x5_12435917342446712151
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nck
* w:None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:
* None_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:nhpasvt_ns_nf:1_nsw:2.0_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:
* None_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mo
* del:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:phpasvt_psb_nf:1_psbw:2.0
************************************************************************
.SUBCKT xf_pcell_issaulsn080ac1d03x5_12435917342446712151 i o s sb vccxx vssxx
*.PININFO i:I o:O s:I sb:I vccxx:B vssxx:B
Mqpsb o sb i vccxx phpasvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mqns o s i vssxx nhpasvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    td_pcell_issaulsn080ac1d03x5_12063697954039380909
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:nhpasvt_nck_nf:1_nck
* w:2.0_ncw:None_nd_model:nhpasvt_nd_nf:1_ndw:2.0_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:phpasvt_pckb_nf:1_pckbw:2.0_pcw:None_pd_model:phpasvt_pd_nf:1_pdw:2.0_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT td_pcell_issaulsn080ac1d03x5_12063697954039380909 ck ckb d o vccxx vssxx
*.PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqpckb o ckb n1 vccxx phpasvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mqpd n1 d vccxx vccxx phpasvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mqnck o ck n2 vssxx nhpasvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mqnd n2 d vssxx vssxx nhpasvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issaulsn080ac1d03x5_13896219110017694169
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:3_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:3_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issaulsn080ac1d03x5_13896219110017694169 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issaulsn080ac1d03x5_14186317100302189950
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:2.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:2.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issaulsn080ac1d03x5_14186317100302189950 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issaulsn080ac1d03x5_558738775049825629
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:2.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:2.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issaulsn080ac1d03x5_558738775049825629 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issaulsn080ac1d03x5
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issaulsn080ac1d03x5_8007251406475222723
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issaulsn080ac1d03x5_8007251406475222723 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issaulohcydp122ab1n00x5
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issaulohcydp122ab1n00x5
* View Name:    schematic
************************************************************************
.SUBCKT issaulohcydp122ab1n00x5 dpd1 vcc vssx
*.PININFO dpd1:I vcc:B vssx:B
Mqngnac1 dpd1 vssx vssx vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issaulodcf33ub1n04x5
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issaulodcf33ub1n04x5
* View Name:    schematic
************************************************************************
.SUBCKT issaulodcf33ub1n04x5 vcc vssx
*.PININFO vcc:I vssx:I
Mqpdecap1 vcc vssx vcc vcc phpalvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    xf_pcell_issaulao4ac1d18x5_1543635324098608011
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nck
* w:None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:
* None_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:nhpasvt_ns_nf:3_nsw:3.0_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:
* None_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mo
* del:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:phpasvt_psb_nf:3_psbw:3.0
************************************************************************
.SUBCKT xf_pcell_issaulao4ac1d18x5_1543635324098608011 i o s sb vccxx vssxx
*.PININFO i:I o:O s:I sb:I vccxx:B vssxx:B
Mqpsb o sb i vccxx phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqns o s i vssxx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issaulao4ac1d18x5_12740764804200976283
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:6_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:6_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issaulao4ac1d18x5_12740764804200976283 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issaulao4ac1d18x5_17870423651273743962
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issaulao4ac1d18x5_17870423651273743962 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issaulao4ac1d18x5_8007251406475222723
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issaulao4ac1d18x5_8007251406475222723 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    td_pcell_issaulao4ac1d18x5_16951344510324896
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:nhpasvt_nck_nf:1_nck
* w:3.0_ncw:None_nd_model:nhpasvt_nd_nf:1_ndw:3.0_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:phpasvt_pckb_nf:1_pckbw:3.0_pcw:None_pd_model:phpasvt_pd_nf:1_pdw:3.0_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT td_pcell_issaulao4ac1d18x5_16951344510324896 ck ckb d o vccxx vssxx
*.PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqpckb o ckb n1 vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpd n1 d vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnck o ck n2 vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnd n2 d vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issaulao4ac1d18x5
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: intel78pgate
* Cell Name:    b2a2no2_pcell_issaulao4ac1d18x5_11408621327718227658
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:3_naw:3.0_nb_model:nhpasvt_nb_nf:3_nbw:3.0_nc_model:nhpasvt_nc_nf:3_nck_model:None_nck_nf:None_nckw:
* None_ncw:3.0_nd_model:nhpasvt_nd_nf:3_ndw:3.0_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:None
* _new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:3_paw:3.0_pb_model:phpasvt_pb_nf:3_pbw:3.0_
* pc_model:phpasvt_pc_nf:3_pckb_model:None_pckb_nf:None_pckbw:None_pcw:3.0_pd_model:phpasvt_pd_nf:3_pdw:3.0_pe_model:None_pe_nf:None_pen_model:Non
* e_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT b2a2no2_pcell_issaulao4ac1d18x5_11408621327718227658 a b c d o vccxx vssxx
*.PININFO a:I b:I c:I d:I o:O vccxx:B vssxx:B
Mqpa o a n0 vccxx phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqpb o b n0 vccxx phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqpc n0 c vccxx vccxx phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqpd n0 d vccxx vccxx phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqnb n3 b vssxx vssxx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqna o a n3 vssxx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqnc o c n2 vssxx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqnd n2 d vssxx vssxx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issaubfnb00ac1n24x5_13896219110017694169
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:3_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:3_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issaubfnb00ac1n24x5_13896219110017694169 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issaubfnb00ac1n24x5
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issaubfnb00ac1n24x5_13940964830582002966
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:8_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:8_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issaubfnb00ac1n24x5_13940964830582002966 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=8 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=8 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    no2_pcell_issastsaegen_15548040510760993482
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:nhpasvt_nb_nf:1_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:phpasvt_pb_nf:1_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT no2_pcell_issastsaegen_15548040510760993482 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb n1 b vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a n1 vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb o b vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    ba2no2_pcell_issastsaegen_16013425243606098825
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:3.0_nb_model:nhpalvt_nb_nf:1_nbw:3.0_nc_model:nhpalvt_nc_nf:1_nck_model:None_nck_nf:None_nckw:
* None_ncw:3.0_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:Non
* e_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:3.0_pb_model:phpalvt_pb_nf:1_pbw:3.0
* _pc_model:phpalvt_pc_nf:1_pckb_model:None_pckb_nf:None_pckbw:None_pcw:3.0_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model:N
* one_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT ba2no2_pcell_issastsaegen_16013425243606098825 a b c o vccxx vssxx
*.PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqpc n1 c vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpb n1 b vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a n1 vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb o b n2 vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnc n2 c vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    na2_pcell_issastsaegen_4654196017136894227
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:3.0_nb_model:nhpalvt_nb_nf:1_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:3.0_pb_model:phpalvt_pb_nf:1_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT na2_pcell_issastsaegen_4654196017136894227 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb o b vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a n1 vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb n1 b vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    no2_pcell_issastsaegen_4654196017136894227
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:3.0_nb_model:nhpalvt_nb_nf:1_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:3.0_pb_model:phpalvt_pb_nf:1_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT no2_pcell_issastsaegen_4654196017136894227 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb n1 b vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a n1 vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb o b vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issabfm806ab1d02x5
* View Name:    schematic
************************************************************************
.SUBCKT issabfm806ab1d02x5 I Z vcc vssx
*.PININFO I:I Z:O vcc:I vssx:I
MMP31 nl1nn nl1 nl1nns vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP01 nl0 inn nl0s vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP50 nl2nns nl2 vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP11 nl0nn nl0 nl0nns vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP21 nl1 nl0nn nl1s vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP51 nl2nn nl2 nl2nns vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP10 nl0nns nl0 vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP30 nl1nns nl1 vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP20 nl1s nl0nn vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP00 nl0s inn vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP41 nl2 nl1nn nl2s vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP1 Z nl2nn vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP40 nl2s nl1nn vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP0 inn I vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN01 nl0 inn nl0s vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN51 nl2nn nl2 nl2nns vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN31 nl1nn nl1 nl1nns vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN21 nl1 nl0nn nl1s vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN40 nl2s nl1nn vssx vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN20 nl1s nl0nn vssx vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN41 nl2 nl1nn nl2s vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN00 nl0s inn vssx vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MM11 nl0nn nl0 nl0nns vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN10 nl0nns nl0 vssx vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN30 nl1nns nl1 vssx vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN0 inn I vssx vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN50 nl2nns nl2 vssx vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN1 Z nl2nn vssx vssx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    na2_pcell_issastsaegen_15109281701568532595
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:3_naw:3.0_nb_model:nhpalvt_nb_nf:3_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:3_paw:3.0_pb_model:phpalvt_pb_nf:3_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT na2_pcell_issastsaegen_15109281701568532595 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb o b vccxx vccxx phpalvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqna o a n1 vssxx nhpalvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mqnb n1 b vssxx vssxx nhpalvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    na2_pcell_issastsaegen_15548040510760993482
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:nhpasvt_nb_nf:1_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:phpasvt_pb_nf:1_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT na2_pcell_issastsaegen_15548040510760993482 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb o b vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a n1 vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb n1 b vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issabfm400ab1d02x5
* View Name:    schematic
************************************************************************
.SUBCKT issabfm400ab1d02x5 I Z vcc vssx
*.PININFO I:I Z:O vcc:I vssx:I
MMN10 nl0nn nl0 vssx vssx nhpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
MMN1 Z nl0nn vssx vssx nhpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
MMN0 inn I vssx vssx nhpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
MMN00 nl0 inn vssx vssx nhpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
MMP10 nl0nn nl0 vcc vcc phpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
MMP1 Z nl0nn vcc vcc phpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
MMP00 nl0 inn vcc vcc phpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
MMP0 inn I vcc vcc phpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issastsaegen_12598931333203620298
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:8_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:8_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issastsaegen_12598931333203620298 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=8 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=8 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issastsaegen_17870423651273743962
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issastsaegen_17870423651273743962 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issastsaegen_558738775049825629
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:2.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:2.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issastsaegen_558738775049825629 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issastsaegen_2751921099722748717
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:2_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:2_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issastsaegen_2751921099722748717 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issastsaegen_8007251406475222723
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issastsaegen_8007251406475222723 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    xf_pcell_issastsaegen_4417371271697137569
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nck
* w:None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:
* None_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:nhpalvt_ns_nf:1_nsw:2.0_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:
* None_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mo
* del:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:phpalvt_psb_nf:1_psbw:2.0
************************************************************************
.SUBCKT xf_pcell_issastsaegen_4417371271697137569 i o s sb vccxx vssxx
*.PININFO i:I o:O s:I sb:I vccxx:B vssxx:B
Mqpsb o sb i vccxx phpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mqns o s i vssxx nhpalvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issastsaegen
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: intel78pgate
* Cell Name:    xf_pcell_issastsaegen_9674134077769332126
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nck
* w:None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:
* None_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:nhpalvt_ns_nf:2_nsw:3.0_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:
* None_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mo
* del:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:phpalvt_psb_nf:2_psbw:3.0
************************************************************************
.SUBCKT xf_pcell_issastsaegen_9674134077769332126 i o s sb vccxx vssxx
*.PININFO i:I o:O s:I sb:I vccxx:B vssxx:B
Mqpsb o sb i vccxx phpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqns o s i vssxx nhpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    bo2na2_pcell_issahcctrk256slc_16013425243606098825
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:3.0_nb_model:nhpalvt_nb_nf:1_nbw:3.0_nc_model:nhpalvt_nc_nf:1_nck_model:None_nck_nf:None_nckw:
* None_ncw:3.0_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:Non
* e_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:3.0_pb_model:phpalvt_pb_nf:1_pbw:3.0
* _pc_model:phpalvt_pc_nf:1_pckb_model:None_pckb_nf:None_pckbw:None_pcw:3.0_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model:N
* one_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT bo2na2_pcell_issahcctrk256slc_16013425243606098825 a b c o vccxx vssxx
*.PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqpb o b n1 vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpc n1 c vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a n0 vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb n0 b vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnc n0 c vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    xf_pcell_issahcctrk256slc_1255097804650392361
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nck
* w:None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:
* None_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:nhpasvt_ns_nf:2_nsw:3.0_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:
* None_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mo
* del:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:phpasvt_psb_nf:2_psbw:3.0
************************************************************************
.SUBCKT xf_pcell_issahcctrk256slc_1255097804650392361 i o s sb vccxx vssxx
*.PININFO i:I o:O s:I sb:I vccxx:B vssxx:B
Mqpsb o sb i vccxx phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqns o s i vssxx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issaudelbuf244pgensvt
* View Name:    schematic
************************************************************************
.SUBCKT issaudelbuf244pgensvt I Z vcc vssx
*.PININFO I:I Z:O vcc:I vssx:I
MMN11 nl0nn I nl0nns vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN10 nl0nns I vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN21 Z nl0nn nl1s vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN20 nl1s nl0nn vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP20 nl1s nl0nn vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP10 nl0nns I vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP21 Z nl0nn nl1s vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP11 nl0nn I nl0nns vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    na2_pcell_issahcctrk256slc_8401311939530474654
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:2_naw:3.0_nb_model:nhpalvt_nb_nf:2_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:2_paw:3.0_pb_model:phpalvt_pb_nf:2_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT na2_pcell_issahcctrk256slc_8401311939530474654 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb o b vccxx vccxx phpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqna o a n1 vssxx nhpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqnb n1 b vssxx vssxx nhpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    na2_pcell_issahcctrk256slc_7500890791422185133
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:2_naw:3.0_nb_model:nhpasvt_nb_nf:2_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:2_paw:3.0_pb_model:phpasvt_pb_nf:2_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT na2_pcell_issahcctrk256slc_7500890791422185133 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb o b vccxx vccxx phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqna o a n1 vssxx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqnb n1 b vssxx vssxx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    na2_pcell_issahcctrk256slc_4654196017136894227
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:3.0_nb_model:nhpalvt_nb_nf:1_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:3.0_pb_model:phpalvt_pb_nf:1_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT na2_pcell_issahcctrk256slc_4654196017136894227 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb o b vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a n1 vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb n1 b vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issahcctrk256slc_4441547943835504324
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:2_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:2_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issahcctrk256slc_4441547943835504324 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issahcctrk256slc_2751921099722748717
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:2_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:2_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issahcctrk256slc_2751921099722748717 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    na2_pcell_issahcctrk256slc_15548040510760993482
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:nhpasvt_nb_nf:1_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:phpasvt_pb_nf:1_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT na2_pcell_issahcctrk256slc_15548040510760993482 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb o b vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a n1 vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb n1 b vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    ba2no2_pcell_issahcctrk256slc_196194420788505470
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:nhpasvt_nb_nf:1_nbw:3.0_nc_model:nhpasvt_nc_nf:1_nck_model:None_nck_nf:None_nckw:
* None_ncw:3.0_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:Non
* e_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:phpasvt_pb_nf:1_pbw:3.0
* _pc_model:phpasvt_pc_nf:1_pckb_model:None_pckb_nf:None_pckbw:None_pcw:3.0_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model:N
* one_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT ba2no2_pcell_issahcctrk256slc_196194420788505470 a b c o vccxx vssxx
*.PININFO a:I b:I c:I o:O vccxx:B vssxx:B
Mqpc n1 c vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpb n1 b vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a n1 vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb o b n2 vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnc n2 c vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    no2_pcell_issahcctrk256slc_15548040510760993482
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:nhpasvt_nb_nf:1_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:phpasvt_pb_nf:1_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT no2_pcell_issahcctrk256slc_15548040510760993482 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb n1 b vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a n1 vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb o b vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issahcctrk256slc_8007251406475222723
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issahcctrk256slc_8007251406475222723 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issaudelbuf224pgensvt
* View Name:    schematic
************************************************************************
.SUBCKT issaudelbuf224pgensvt I Z vcc vssx
*.PININFO I:I Z:O vcc:I vssx:I
MMN01 Z inn nl0s vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN0 inn I vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMN00 nl0s inn vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP00 nl0s inn vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP01 Z inn nl0s vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
MMP0 inn I vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issahcctrk256slc_17870423651273743962
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issahcctrk256slc_17870423651273743962 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    xf_pcell_issahcctrk256slc_1534216117833948629
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nck
* w:None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:
* None_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:nhpalvt_ns_nf:1_nsw:3.0_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:
* None_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mo
* del:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:phpalvt_psb_nf:1_psbw:3.0
************************************************************************
.SUBCKT xf_pcell_issahcctrk256slc_1534216117833948629 i o s sb vccxx vssxx
*.PININFO i:I o:O s:I sb:I vccxx:B vssxx:B
Mqpsb o sb i vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqns o s i vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    no2_pcell_issahcctrk256slc_12795608570872162145
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:4_naw:3.0_nb_model:nhpasvt_nb_nf:4_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:4_paw:3.0_pb_model:phpasvt_pb_nf:4_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT no2_pcell_issahcctrk256slc_12795608570872162145 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb n1 b vccxx vccxx phpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mqpa o a n1 vccxx phpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mqnb o b vssxx vssxx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    no2_pcell_issahcctrk256slc_8401311939530474654
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:2_naw:3.0_nb_model:nhpalvt_nb_nf:2_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:2_paw:3.0_pb_model:phpalvt_pb_nf:2_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT no2_pcell_issahcctrk256slc_8401311939530474654 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb n1 b vccxx vccxx phpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqpa o a n1 vccxx phpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqnb o b vssxx vssxx nhpalvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issahcctrk256slc
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: intel78pgate
* Cell Name:    no2_pcell_issahcctrk256slc_4654196017136894227
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:3.0_nb_model:nhpalvt_nb_nf:1_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:3.0_pb_model:phpalvt_pb_nf:1_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT no2_pcell_issahcctrk256slc_4654196017136894227 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb n1 b vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a n1 vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb o b vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issahccsiocm4lya
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issahccsiocm4lya_8007251406475222723
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issahccsiocm4lya_8007251406475222723 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issahcclyal2mux
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issahcclyal2mux_14186317100302189950
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:2.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:2.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issahcclyal2mux_14186317100302189950 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=2.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issahcclyal1muxn2n_8007251406475222723
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issahcclyal1muxn2n_8007251406475222723 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issahcclyal1muxn2n
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: intel78pgate
* Cell Name:    na2_pcell_issahcclyal1muxn2n_15548040510760993482
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:nhpasvt_nb_nf:1_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:phpasvt_pb_nf:1_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT na2_pcell_issahcclyal1muxn2n_15548040510760993482 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb o b vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a n1 vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb n1 b vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    xf_pcell_issahccciocm4_1534216117833948629
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nck
* w:None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:
* None_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:nhpalvt_ns_nf:1_nsw:3.0_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:
* None_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mo
* del:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:phpalvt_psb_nf:1_psbw:3.0
************************************************************************
.SUBCKT xf_pcell_issahccciocm4_1534216117833948629 i o s sb vccxx vssxx
*.PININFO i:I o:O s:I sb:I vccxx:B vssxx:B
Mqpsb o sb i vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqns o s i vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    td_pcell_issahccciocm4_146937493879050003
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:nhpalvt_nck_nf:1_nck
* w:3.0_ncw:None_nd_model:nhpalvt_nd_nf:1_ndw:3.0_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:phpalvt_pckb_nf:1_pckbw:3.0_pcw:None_pd_model:phpalvt_pd_nf:1_pdw:3.0_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT td_pcell_issahccciocm4_146937493879050003 ck ckb d o vccxx vssxx
*.PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqpckb o ckb n1 vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpd n1 d vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnck o ck n2 vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnd n2 d vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    no2_pcell_issahccciocm4_7500890791422185133
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:2_naw:3.0_nb_model:nhpasvt_nb_nf:2_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:2_paw:3.0_pb_model:phpasvt_pb_nf:2_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT no2_pcell_issahccciocm4_7500890791422185133 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb n1 b vccxx vccxx phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqpa o a n1 vccxx phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mqnb o b vssxx vssxx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    no2_pcell_issahccciocm4_15548040510760993482
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:nhpasvt_nb_nf:1_nbw:3.0_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw:
* None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:phpasvt_pb_nf:1_pbw:3.
* 0_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT no2_pcell_issahccciocm4_15548040510760993482 a b o vccxx vssxx
*.PININFO a:I b:I o:O vccxx:B vssxx:B
Mqpb n1 b vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa o a n1 vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb o b vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    xf_pcell_issahccciocm4_6852071075964942753
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nck
* w:None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:
* None_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:nhpasvt_ns_nf:1_nsw:3.0_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:
* None_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mo
* del:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:phpasvt_psb_nf:1_psbw:3.0
************************************************************************
.SUBCKT xf_pcell_issahccciocm4_6852071075964942753 i o s sb vccxx vssxx
*.PININFO i:I o:O s:I sb:I vccxx:B vssxx:B
Mqpsb o sb i vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqns o s i vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    td_pcell_issahccciocm4_16951344510324896
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:None_na_nf:None_naw:None_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:nhpasvt_nck_nf:1_nck
* w:3.0_ncw:None_nd_model:nhpasvt_nd_nf:1_ndw:3.0_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:No
* ne_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:None_pa_nf:None_paw:None_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:phpasvt_pckb_nf:1_pckbw:3.0_pcw:None_pd_model:phpasvt_pd_nf:1_pdw:3.0_pe_model:None_pe_nf:None_pen_model
* :None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT td_pcell_issahccciocm4_16951344510324896 ck ckb d o vccxx vssxx
*.PININFO ck:I ckb:I d:I o:O vccxx:B vssxx:B
Mqpckb o ckb n1 vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpd n1 d vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnck o ck n2 vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnd n2 d vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issahccciocm4_9999192332891373312
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:4_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:4_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issahccciocm4_9999192332891373312 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issahccciocm4_17870423651273743962
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpalvt_na_nf:1_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpalvt_pa_nf:1_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issahccciocm4_17870423651273743962 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issahccciocm4
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: intel78pgate
* Cell Name:    inv_pcell_issahccciocm4_8007251406475222723
* View Name:    schematic
* _lvsExactMatch:FALSE_na_model:nhpasvt_na_nf:1_naw:3.0_nb_model:None_nb_nf:None_nbw:None_nc_model:None_nc_nf:None_nck_model:None_nck_nf:None_nckw
* :None_ncw:None_nd_model:None_nd_nf:None_ndw:None_ne1_model:None_ne1_nf:None_ne1w:None_ne2_model:None_ne2_nf:None_ne2w:None_ne_model:None_ne_nf:N
* one_new:None_ni_model:None_ni_nf:None_niw:None_ns_model:None_ns_nf:None_nsw:None_pa_model:phpasvt_pa_nf:1_paw:3.0_pb_model:None_pb_nf:None_pbw:N
* one_pc_model:None_pc_nf:None_pckb_model:None_pckb_nf:None_pckbw:None_pcw:None_pd_model:None_pd_nf:None_pdw:None_pe_model:None_pe_nf:None_pen_mod
* el:None_pen_nf:None_penw:None_pew:None_pi_model:None_pi_nf:None_piw:None_psb_model:None_psb_nf:None_psbw:None
************************************************************************
.SUBCKT inv_pcell_issahccciocm4_8007251406475222723 a o vccxx vssxx
*.PININFO a:I o:O vccxx:B vssxx:B
Mqpa o a vccxx vccxx phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqna o a vssxx vssxx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5bitfe
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5bitfe bl bl_b sramvcc sramvss wl
*.PININFO bl:B bl_b:B sramvcc:I sramvss:I wl:I
Mimn0 n0 n1 sramvss sramvss nhpsrhcc5 W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mimxn0 bl wl n0 sramvss nhpsrhcc5 W=1.0 L=14n M=1 LVSEXACTMATCH=0
Mimxn1 bl_b wl n1 sramvss nhpsrhcc5 W=1.0 L=14n M=1 LVSEXACTMATCH=0
Mimn1 n1 n0 sramvss sramvss nhpsrhcc5 W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mimp0 n0 n1 sramvcc sramvcc phpsrhcc5 W=1.0 L=14n M=1 LVSEXACTMATCH=0
Mimp1 n1 n0 sramvcc sramvcc phpsrhcc5 W=1.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5edgfe
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5edgfe bl sramvcc sramvss
*.PININFO bl:B sramvcc:I sramvss:I
Mmn0 nocon1 sramvss bl sramvss nhpsrhcc5 W=1.0 L=14n M=1 LVSEXACTMATCH=0
Mmn1 sramvss nocon3 sramvss sramvss nhpsrhcc5 W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mmp0 sramvcc nocon3 nocon2 sramvcc phpsrhcc5 W=1.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5trkfe
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5trkfe bl_nc dbl dwl sramvcc sramvss wlnc
*.PININFO bl_nc:B dbl:B dwl:I sramvcc:I sramvss:I wlnc:I
Mimn1 sramvcc n0 sramvss sramvss nhpsrhcc5 W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mimn0 n0 sramvcc sramvss sramvss nhpsrhcc5 W=2.0 L=14n M=1 LVSEXACTMATCH=0
Mimxn1 bl_nc wlnc sramvcc sramvss nhpsrhcc5 W=1.0 L=14n M=1 LVSEXACTMATCH=0
Mimxn0 dbl dwl n0 sramvss nhpsrhcc5 W=1.0 L=14n M=1 LVSEXACTMATCH=0
Mimp1 sramvcc n0 sramvcc sramvcc phpsrhcc5 W=1.0 L=14n M=1 LVSEXACTMATCH=0
Mimp0 n0 sramvcc sramvcc sramvcc phpsrhcc5 W=1.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_timer_dcap_container vcc vss
*.PININFO vcc:I vss:I
Xdcapcell_19445 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19444 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19443 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_19442 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_19441 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19440 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19439 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19438 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19437 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19436 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19435 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19434 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19433 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19432 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19431 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19430 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19429 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19428 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19427 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19425 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19424 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19423 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19422 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19421 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19420 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19419 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19418 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19417 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19416 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19415 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19414 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19413 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19412 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19411 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19410 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19409 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19408 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19407 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19406 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_19405 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19404 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19403 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19402 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19401 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19400 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19399 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19398 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19397 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19396 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19395 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19394 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19393 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19392 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19391 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19390 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19389 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19388 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19387 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_19386 vcc vss i0mzdcf33ub1n32x5
Xdcapcell_19385 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19384 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19383 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19382 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19381 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19380 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19379 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19378 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_19377 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_19376 vcc vss i0mzdcf33ub1n04x5
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_giocntrl_dcap_container vcc vss
*.PININFO vcc:I vss:I
Xdcapcell_436 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_437 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_438 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_439 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_440 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_441 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_442 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_443 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_444 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_445 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_446 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_447 vcc vss i0mzdcf33ub1n16x5
Xdcapcell_448 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_449 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_450 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_451 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_452 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_454 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_455 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_456 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_457 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_458 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_459 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_460 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_461 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_462 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_463 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_464 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_465 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_466 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_467 vcc vss i0mzdcf33ub1n08x5
Xdcapcell_468 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_469 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_470 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_471 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_472 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_473 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_474 vcc vss i0mzdcf33ub1n04x5
Xdcapcell_475 vcc vss i0mzdcf33ub1n04x5
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_sidetimer activered1l[1] activered1l[0]
+ blpch clkrd clksaemx clkwl clkwrysel# fz_syncrd pcnn_dn pcnn_up rdysel_dn[3] rdysel_dn[2]
+ rdysel_dn[1] rdysel_dn[0] rdysel_up[3] rdysel_up[2] rdysel_up[1] rdysel_up[0]
+ redactive1l# sideenable1l slpen slpen1l# vcc vss wle[3] wle[2] wle[1] wle[0] wleaddrdec[3]
+ wleaddrdec[2] wleaddrdec[1] wleaddrdec[0] wlered[1] wlered[0] wrcolsel_dn[3] wrcolsel_dn[2]
+ wrcolsel_dn[1] wrcolsel_dn[0] wrcolsel_up[3] wrcolsel_up[2] wrcolsel_up[1] wrcolsel_up[0]
+ yseladdrdec[3] yseladdrdec[2] yseladdrdec[1] yseladdrdec[0]
*.PININFO activered1l[1]:I activered1l[0]:I blpch:I clkrd:I clksaemx:I clkwl:I clkwrysel#:I fz_syncrd:I pcnn_dn:O pcnn_up:O rdysel_dn[3]:O rdysel_dn[2]:O rdysel_dn[1]:O rdysel_dn[0]:O rdysel_up[3]:O rdysel_up[2]:O rdysel_up[1]:O rdysel_up[0]:O redactive1l#:I sideenable1l:I
*.PININFO slpen:O slpen1l#:I vcc:I vss:I wle[3]:O wle[2]:O wle[1]:O wle[0]:O wleaddrdec[3]:I wleaddrdec[2]:I wleaddrdec[1]:I wleaddrdec[0]:I wlered[1]:O wlered[0]:O wrcolsel_dn[3]:O wrcolsel_dn[2]:O wrcolsel_dn[1]:O wrcolsel_dn[0]:O wrcolsel_up[3]:O wrcolsel_up[2]:O
*.PININFO wrcolsel_up[1]:O wrcolsel_up[0]:O yseladdrdec[3]:I yseladdrdec[2]:I yseladdrdec[1]:I yseladdrdec[0]:I
Xirep2 sideenable1l# sideenable1l_rep# vcc vss i0mbfm201ab1n03x5
Xirep0 slpen_rep# slpen_rep_rep# vcc vss i0mbfm201ac1n03x5
Xirep1 slpen_rep_rep# slpen_rep_rep_rep# vcc vss i0mbfm201ac1n02x5
Xwlreddrv[1] clkwle# activered1l_b[1] wlered_del[1] vcc vss i0mnor002ab1n03x5
Xwlreddrv[0] clkwle# activered1l_b[0] wlered_del[0] vcc vss i0mnor002ab1n03x5
Xwlredinv[1] activered1l[1] activered1l_b[1] vcc vss i0minv000ac1n02x5
Xwlredinv[0] activered1l[0] activered1l_b[0] vcc vss i0minv000ac1n02x5
Xwlenanddrv[3] clkwl wleaddrdec[3] wlenn[3] vcc vss i0mnand02ab1n06x5
Xwlenanddrv[2] clkwl wleaddrdec[2] wlenn[2] vcc vss i0mnand02ab1n06x5
Xwlenanddrv[1] clkwl wleaddrdec[1] wlenn[1] vcc vss i0mnand02ab1n06x5
Xwlenanddrv[0] clkwl wleaddrdec[0] wlenn[0] vcc vss i0mnand02ab1n06x5
Xsideengen sideenable1l sideenable1l# vcc vss i0minv000ac1n09x5
Xiwlclkgen clkwl sideenable1l clkwle# vcc vss i0mnand02ab1n03x5
Xsideenable1llatch blpch sideenable1l# sideenable1l_cg# vcc vss i0mlsn000ac1n03x5
Xipchand blpch sideenable1l_cg# pc# vcc vss i0mnor002ab1n06x5
Xipcdrvup pc# pcnn_up vcc vss i0mbfn000ab1n30x5
Xipcdrvdn pc# pcnn_dn vcc vss i0mbfn000ab1n30x5
Xiclkrd clkrd sideenable1l clkrdysel# vcc vss i0mnand02ab1n06x5
Xiclkwr clkwrysel# sideenable1l_del# clkwrysel vcc vss i0mnor002ab1n10x5
Xislpen1l slpen1l# sideenable1l slpen1l vcc vss i0mnand02ab1n03x5
Xiredactgen redactive1l# sideenable1l redactive vcc vss i0mnand02ab1n03x5
Xislpen slpen1l slpen# vcc vss i0minv000ac1n03x5
Xislpendrv slpen# slpen_del1# slpen vcc vss i0mnor002ab1n06x5
Xiwrcoldrvup[0] wrcolsel#[0] wrcolsel_up[0] vcc vss i0minv000ab1n30x5
Xiwrcoldrvdn[0] wrcolsel#[0] wrcolsel_dn[0] vcc vss i0minv000ab1n30x5
Xiwrcoldrv[0] clkwrysel yseladdrdec[0] wrcolsel#[0] vcc vss i0mnand02ab1n10x5
Xirdyseldrv[0] clkrdysel yseladdrdec[0] rdysel#[0] vcc vss i0mnand02ab1n12x5
Xirdyseldrvup[0] rdysel#[0] rdysel_up[0] vcc vss i0minv000ab1n30x5
Xirdyseldrvdn[0] rdysel#[0] rdysel_dn[0] vcc vss i0minv000ab1n30x5
Xiwrcoldrvup[1] wrcolsel#[1] wrcolsel_up[1] vcc vss i0minv000ab1n30x5
Xiwrcoldrvdn[1] wrcolsel#[1] wrcolsel_dn[1] vcc vss i0minv000ab1n30x5
Xiwrcoldrv[1] clkwrysel yseladdrdec[1] wrcolsel#[1] vcc vss i0mnand02ab1n10x5
Xirdyseldrv[1] clkrdysel yseladdrdec[1] rdysel#[1] vcc vss i0mnand02ab1n12x5
Xirdyseldrvup[1] rdysel#[1] rdysel_up[1] vcc vss i0minv000ab1n30x5
Xirdyseldrvdn[1] rdysel#[1] rdysel_dn[1] vcc vss i0minv000ab1n30x5
Xiwrcoldrvup[2] wrcolsel#[2] wrcolsel_up[2] vcc vss i0minv000ab1n30x5
Xiwrcoldrvdn[2] wrcolsel#[2] wrcolsel_dn[2] vcc vss i0minv000ab1n30x5
Xiwrcoldrv[2] clkwrysel yseladdrdec[2] wrcolsel#[2] vcc vss i0mnand02ab1n10x5
Xirdyseldrv[2] clkrdysel yseladdrdec[2] rdysel#[2] vcc vss i0mnand02ab1n12x5
Xirdyseldrvup[2] rdysel#[2] rdysel_up[2] vcc vss i0minv000ab1n30x5
Xirdyseldrvdn[2] rdysel#[2] rdysel_dn[2] vcc vss i0minv000ab1n30x5
Xiwrcoldrvup[3] wrcolsel#[3] wrcolsel_up[3] vcc vss i0minv000ab1n30x5
Xiwrcoldrvdn[3] wrcolsel#[3] wrcolsel_dn[3] vcc vss i0minv000ab1n30x5
Xiwrcoldrv[3] clkwrysel yseladdrdec[3] wrcolsel#[3] vcc vss i0mnand02ab1n10x5
Xirdyseldrv[3] clkrdysel yseladdrdec[3] rdysel#[3] vcc vss i0mnand02ab1n12x5
Xirdyseldrvup[3] rdysel#[3] rdysel_up[3] vcc vss i0minv000ab1n30x5
Xirdyseldrvdn[3] rdysel#[3] rdysel_dn[3] vcc vss i0minv000ab1n30x5
Xiwle[3] wlenn[3] redactive wle[3] vcc vss i0mnor002ab1n06x5
Xiwle[2] wlenn[2] redactive wle[2] vcc vss i0mnor002ab1n06x5
Xiwle[1] wlenn[1] redactive wle[1] vcc vss i0mnor002ab1n06x5
Xiwle[0] wlenn[0] redactive wle[0] vcc vss i0mnor002ab1n06x5
Xiclkrdysel clkrdysel# clksaemx fz_syncrd clkrdysel vcc vss i0maoi012ab1n09x5
Xiclkwr_mdb sideenable1l_rep# sideenable1l_del# vcc vss i0mbfm402ac1n03x5
Xislpen_del slpen_rep_rep_rep# slpen_del1# vcc vss i0mbfm402ac1n03x5
Xwlreddel[0] wlered_del[0] wlered[0] vcc vss i0mbfm402ac1n03x5
Xwlreddel[1] wlered_del[1] wlered[1] vcc vss i0mbfm402ac1n03x5
Xirep slpen# slpen_rep# vcc vss i0mbfm201ac1n03x5
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issax2dec2
* View Name:    schematic
************************************************************************
.SUBCKT issax2dec2 c6save decvcc slpen vcc vssx wl[1] wl[0] wllvlnn[2] wllvlnn[1]
+ wllvlnn[0] wlnn[1] wlnn[0]
*.PININFO c6save:I decvcc:B slpen:I vcc:I vssx:I wl[1]:O wl[0]:O wllvlnn[2]:I wllvlnn[1]:I wllvlnn[0]:I wlnn[1]:I wlnn[0]:I
Xdec0 c6save decvcc slpen vcc vssx wl[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlnn[0] issax2dec1
Xdec1 c6save decvcc slpen vcc vssx wl[1] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlnn[1] issax2dec1
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issaxdecrepeaters
* View Name:    schematic
************************************************************************
.SUBCKT issaxdecrepeaters slpen slpennn vcc vssx wlein[3] wlein[2] wlein[1] wlein[0]
+ wleout[3] wleout[2] wleout[1] wleout[0] wllvlin[2] wllvlin[1] wllvlin[0] wllvlout[2]
+ wllvlout[1] wllvlout[0]
*.PININFO slpen:O slpennn:I vcc:I vssx:I wlein[3]:I wlein[2]:I wlein[1]:I wlein[0]:I wleout[3]:O wleout[2]:O wleout[1]:O wleout[0]:O wllvlin[2]:I wllvlin[1]:I wllvlin[0]:I wllvlout[2]:O wllvlout[1]:O wllvlout[0]:O
Xwllvlinv[0] wllvlin[0] wllvlout[0] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xslpinv slpennn slpen vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xwllvlinv[1] wllvlin[1] wllvlout[1] vcc vssx inv_pcell_issax2dec256_13896219110017694169
Xwleinv[3] wlein[3] wleout[3] vcc vssx inv_pcell_issax2dec256_12740764804200976283
Xwleinv[2] wlein[2] wleout[2] vcc vssx inv_pcell_issax2dec256_12740764804200976283
Xwleinv[1] wlein[1] wleout[1] vcc vssx inv_pcell_issax2dec256_12740764804200976283
Xwleinv[0] wlein[0] wleout[0] vcc vssx inv_pcell_issax2dec256_12740764804200976283
Xwllvlinv[2] wllvlin[2] wllvlout[2] vcc vssx inv_pcell_issax2dec256_4441547943835504324
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issaxdecdrivers
* View Name:    schematic
************************************************************************
.SUBCKT issaxdecdrivers hiin[7] hiin[6] hiin[5] hiin[4] hiin[3] hiin[2] hiin[1] hiin[0]
+ hiout[7] hiout[6] hiout[5] hiout[4] hiout[3] hiout[2] hiout[1] hiout[0] midin[7]
+ midin[6] midin[5] midin[4] midin[3] midin[2] midin[1] midin[0] midout[7] midout[6]
+ midout[5] midout[4] midout[3] midout[2] midout[1] midout[0] slpenin slpenout vcc
+ vssx wlein[3] wlein[2] wlein[1] wlein[0] wleout[3] wleout[2] wleout[1] wleout[0]
+ wllvlin[2] wllvlin[1] wllvlin[0] wllvlout[2] wllvlout[1] wllvlout[0]
*.PININFO hiin[7]:I hiin[6]:I hiin[5]:I hiin[4]:I hiin[3]:I hiin[2]:I hiin[1]:I hiin[0]:I hiout[7]:O hiout[6]:O hiout[5]:O hiout[4]:O hiout[3]:O hiout[2]:O hiout[1]:O hiout[0]:O midin[7]:I midin[6]:I midin[5]:I midin[4]:I
*.PININFO midin[3]:I midin[2]:I midin[1]:I midin[0]:I midout[7]:O midout[6]:O midout[5]:O midout[4]:O midout[3]:O midout[2]:O midout[1]:O midout[0]:O slpenin:I slpenout:O vcc:B vssx:B wlein[3]:I wlein[2]:I wlein[1]:I wlein[0]:I
*.PININFO wleout[3]:O wleout[2]:O wleout[1]:O wleout[0]:O wllvlin[2]:I wllvlin[1]:I wllvlin[0]:I wllvlout[2]:O wllvlout[1]:O wllvlout[0]:O
Xhiinv[3] hiin[3] hiout[3] vcc vssx inv_pcell_issax2dec256_13896219110017694169
Xhiinv[2] hiin[2] hiout[2] vcc vssx inv_pcell_issax2dec256_13896219110017694169
Xhiinv[1] hiin[1] hiout[1] vcc vssx inv_pcell_issax2dec256_13896219110017694169
Xhiinv[0] hiin[0] hiout[0] vcc vssx inv_pcell_issax2dec256_13896219110017694169
Xhiinv[7] hiin[7] hiout[7] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xhiinv[6] hiin[6] hiout[6] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xhiinv[5] hiin[5] hiout[5] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xhiinv[4] hiin[4] hiout[4] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xmidinv[7] midin[7] midout[7] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xmidinv[6] midin[6] midout[6] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xmidinv[5] midin[5] midout[5] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xmidinv[4] midin[4] midout[4] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xmidinv[3] midin[3] midout[3] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xmidinv[2] midin[2] midout[2] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xmidinv[1] midin[1] midout[1] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xmidinv[0] midin[0] midout[0] vcc vssx inv_pcell_issax2dec256_9999192332891373312
Xslpinv slpenin slpenout vcc vssx inv_pcell_issax2dec256_13120004337063829235
Xwleinv[3] wlein[3] wleout[3] vcc vssx inv_pcell_issax2dec256_7480748400340743147
Xwleinv[2] wlein[2] wleout[2] vcc vssx inv_pcell_issax2dec256_7480748400340743147
Xwleinv[1] wlein[1] wleout[1] vcc vssx inv_pcell_issax2dec256_7480748400340743147
Xwleinv[0] wlein[0] wleout[0] vcc vssx inv_pcell_issax2dec256_7480748400340743147
Xwllvlinv[2] wllvlin[2] wllvlout[2] vcc vssx inv_pcell_issax2dec256_13896219110017694169
Xwllvlinv[1] wllvlin[1] wllvlout[1] vcc vssx inv_pcell_issax2dec256_13896219110017694169
Xwllvlinv[0] wllvlin[0] wllvlout[0] vcc vssx inv_pcell_issax2dec256_13896219110017694169
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issaulsn080ac1d03x5
* View Name:    schematic
************************************************************************
.SUBCKT issaulsn080ac1d03x5 clkb d o1 vcc vssx
*.PININFO clkb:I d:I o1:O vcc:I vssx:I
Xg2 d n3 vcc vssx inv_pcell_issaulsn080ac1d03x5_8007251406475222723
Xg1 clkb nc1 vcc vssx inv_pcell_issaulsn080ac1d03x5_558738775049825629
Xg2lp1 nk1 nk2 vcc vssx inv_pcell_issaulsn080ac1d03x5_14186317100302189950
Xg101 nk1 o1 vcc vssx inv_pcell_issaulsn080ac1d03x5_13896219110017694169
Xg3lp1 clkb nc1 nk2 nk1 vcc vssx td_pcell_issaulsn080ac1d03x5_12063697954039380909
Xg1lp1 n3 nk1 nc1 clkb vcc vssx xf_pcell_issaulsn080ac1d03x5_12435917342446712151
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice_dcap_container vcc vss
*.PININFO vcc:I vss:I
Xdcapcell_14368 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14367 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14366 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14365 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14364 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14363 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14362 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14361 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14360 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14359 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14358 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14357 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14356 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14355 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14354 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14353 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14352 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14351 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14350 vcc vss issaulodcf33ub1n04x5
Xdcapcell_14349 vcc vss issaulodcf33ub1n04x5
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issaulao4ac1d18x5
* View Name:    schematic
************************************************************************
.SUBCKT issaulao4ac1d18x5 clk d0 d1 o sd0nn sd1nn vcc vssx
*.PININFO clk:I d0:I d1:I o:O sd0nn:I sd1nn:I vcc:B vssx:B
Ximuxdata d1 sd1 d0 sd0 n4 vcc vssx b2a2no2_pcell_issaulao4ac1d18x5_11408621327718227658
Xisustri nc0 nc1 nk2 nk1 vcc vssx td_pcell_issaulao4ac1d18x5_16951344510324896
Xiselinv0 sd0nn sd0 vcc vssx inv_pcell_issaulao4ac1d18x5_8007251406475222723
Xiclkinv1 nc0 nc1 vcc vssx inv_pcell_issaulao4ac1d18x5_17870423651273743962
Xiselinv1 sd1nn sd1 vcc vssx inv_pcell_issaulao4ac1d18x5_8007251406475222723
Xisusinv nk1 nk2 vcc vssx inv_pcell_issaulao4ac1d18x5_8007251406475222723
Xiodoutdrv nk1 o vcc vssx inv_pcell_issaulao4ac1d18x5_12740764804200976283
Xiclkinv0 clk nc0 vcc vssx inv_pcell_issaulao4ac1d18x5_17870423651273743962
Xipgd n4 nk1 nc1 nc0 vcc vssx xf_pcell_issaulao4ac1d18x5_1543635324098608011
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issaubfnb00ac1n24x5
* View Name:    schematic
************************************************************************
.SUBCKT issaubfnb00ac1n24x5 a o vcc vssx
*.PININFO a:I o:O vcc:I vssx:I
Xg1 n1 o vcc vssx inv_pcell_issaubfnb00ac1n24x5_13940964830582002966
Xg0 a n1 vcc vssx inv_pcell_issaubfnb00ac1n24x5_13896219110017694169
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issasaerdl
* View Name:    schematic
************************************************************************
.SUBCKT issasaerdl sae setnn trig vcc vssx
*.PININFO sae:O setnn:I trig:I vcc:I vssx:I
Xir cpdfb trig fb vcc vssx no2_pcell_issastsaegen_4654196017136894227
Xisb setnn fb cpdfb vcc vssx no2_pcell_issastsaegen_4654196017136894227
Xirn_ set fb fbn vcc vssx na2_pcell_issastsaegen_4654196017136894227
Xirb fbn setnn znn sae vcc vssx ba2no2_pcell_issastsaegen_16013425243606098825
Xirn setnn set vcc vssx inv_pcell_issastsaegen_17870423651273743962
Xifb sae znn vcc vssx inv_pcell_issastsaegen_17870423651273743962
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issastbypassrdl
* View Name:    schematic
************************************************************************
.SUBCKT issastbypassrdl async sync trig trkwlnn vcc vssx wlin
*.PININFO async:I sync:I trig:I trkwlnn:O vcc:I vssx:I wlin:I
Xir async trig cpdfb fb vcc vssx bo2na2_pcell_issahcctrk256slc_16013425243606098825
Xirb fb wlin znn trkwlnn vcc vssx bo2na2_pcell_issahcctrk256slc_16013425243606098825
Xifb sync trkwlnn znn vcc vssx no2_pcell_issahcctrk256slc_4654196017136894227
Xisb set fb cpdfb vcc vssx no2_pcell_issahcctrk256slc_4654196017136894227
Xisetb wlin set vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issawrstdtrkdl
* View Name:    schematic
************************************************************************
.SUBCKT issawrstdtrkdl nblkicknn s[1] s[0] trigwr vcc vssx
*.PININFO nblkicknn:I s[1]:I s[0]:I trigwr:O vcc:I vssx:I
Xidd nblkicknn net1 vcc vssx issaudelbuf224pgensvt
Xg0 n1 nnn2 vcc vssx inv_pcell_issahcctrk256slc_8007251406475222723
Xg3 nnn1 n1 vcc vssx inv_pcell_issahcctrk256slc_8007251406475222723
Xitrigwr trigwrnn trigwr vcc vssx inv_pcell_issahcctrk256slc_8007251406475222723
Xg4 nnn0 n0 vcc vssx inv_pcell_issahcctrk256slc_8007251406475222723
Xrst net1 nblkicknn nnn0 vcc vssx no2_pcell_issahcctrk256slc_15548040510760993482
Xitrigdel n1 n2 s[0] nnn3 vcc vssx ba2no2_pcell_issahcctrk256slc_196194420788505470
Xg1 nnn2 nnn0 n2 vcc vssx na2_pcell_issahcctrk256slc_15548040510760993482
Xg2 n0 s[1] nnn1 vcc vssx na2_pcell_issahcctrk256slc_15548040510760993482
Xitrigwrnn nnn3 nnn0 trigwrnn vcc vssx na2_pcell_issahcctrk256slc_15548040510760993482
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issafinemux
* View Name:    schematic
************************************************************************
.SUBCKT issafinemux IB IF S SB ZNB ZNF vcc vssx
*.PININFO IB:I IF:I S:I SB:I ZNB:O ZNF:O vcc:I vssx:I
Xifpg IF tgo S SB vcc vssx xf_pcell_issahcctrk256slc_1534216117833948629
Xibkpg IB tgo SB S vcc vssx xf_pcell_issahcctrk256slc_1534216117833948629
Xiznb tgo ZNB vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
Xiznf IF ZNF vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issalastfinemux
* View Name:    schematic
************************************************************************
.SUBCKT issalastfinemux IB IF S SB ZNB vcc vssx
*.PININFO IB:I IF:I S:I SB:I ZNB:O vcc:I vssx:I
Xifpg IF tgo S SB vcc vssx xf_pcell_issahcctrk256slc_1534216117833948629
Xibkpg IB tgo SB S vcc vssx xf_pcell_issahcctrk256slc_1534216117833948629
Xiznb tgo ZNB vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahcciordyselx4
* View Name:    schematic
************************************************************************
.SUBCKT issahcciordyselx4 bl[3] bl[2] bl[1] bl[0] blnn[3] blnn[2] blnn[1] blnn[0]
+ inbl inblnn rdcolsel[3] rdcolsel[2] rdcolsel[1] rdcolsel[0] vcc vssx
*.PININFO bl[3]:B bl[2]:B bl[1]:B bl[0]:B blnn[3]:B blnn[2]:B blnn[1]:B blnn[0]:B inbl:B inblnn:B rdcolsel[3]:I rdcolsel[2]:I rdcolsel[1]:I rdcolsel[0]:I vcc:I vssx:I
Mirdmuxbl[3] inbl rdcolselnn[3] bl[3] vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mirdmuxbl[2] inbl rdcolselnn[2] bl[2] vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mirdmuxbl[1] inbl rdcolselnn[1] bl[1] vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mirdmuxbl[0] inbl rdcolselnn[0] bl[0] vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mirdmuxblnn[3] inblnn rdcolselnn[3] blnn[3] vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mirdmuxblnn[2] inblnn rdcolselnn[2] blnn[2] vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mirdmuxblnn[1] inblnn rdcolselnn[1] blnn[1] vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mirdmuxblnn[0] inblnn rdcolselnn[0] blnn[0] vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Xirdysel[3] rdcolsel[3] rdcolselnn[3] vcc vssx inv_pcell_issahccsiocm4lya_8007251406475222723
Xirdysel[2] rdcolsel[2] rdcolselnn[2] vcc vssx inv_pcell_issahccsiocm4lya_8007251406475222723
Xirdysel[1] rdcolsel[1] rdcolselnn[1] vcc vssx inv_pcell_issahccsiocm4lya_8007251406475222723
Xirdysel[0] rdcolsel[0] rdcolselnn[0] vcc vssx inv_pcell_issahccsiocm4lya_8007251406475222723
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccioblpch4
* View Name:    schematic
************************************************************************
.SUBCKT issahccioblpch4 bl[3] bl[2] bl[1] bl[0] blnn[3] blnn[2] blnn[1] blnn[0] pcnn
+ vcc vssx
*.PININFO bl[3]:B bl[2]:B bl[1]:B bl[0]:B blnn[3]:B blnn[2]:B blnn[1]:B blnn[0]:B pcnn:I vcc:I vssx:I
Xipchnninv pcnn blpc vcc vssx inv_pcell_issahccsiocm4lya_8007251406475222723
Miblpch[3] bl[3] blpcnn vcc vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miblpch[2] bl[2] blpcnn vcc vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miblpch[1] bl[1] blpcnn vcc vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miblpch[0] bl[0] blpcnn vcc vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mippchinv blpcnn blpc vcc vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miblpcheq[3] blnn[3] blpcnn bl[3] vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miblpcheq[2] blnn[2] blpcnn bl[2] vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miblpcheq[1] blnn[1] blpcnn bl[1] vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miblpcheq[0] blnn[0] blpcnn bl[0] vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miblpchnn[3] blnn[3] blpcnn vcc vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miblpchnn[2] blnn[2] blpcnn vcc vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miblpchnn[1] blnn[1] blpcnn vcc vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miblpchnn[0] blnn[0] blpcnn vcc vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Minpchinv blpcnn blpc vssx vssx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahcciowryselx4lya
* View Name:    schematic
************************************************************************
.SUBCKT issahcciowryselx4lya bl[3] bl[2] bl[1] bl[0] blnn[3] blnn[2] blnn[1] blnn[0]
+ decnvss lyaenbit lyal0bl lyal0blnn nvss vcc vssx wrcolsel[3] wrcolsel[2] wrcolsel[1]
+ wrcolsel[0] wrdata wrdatann
*.PININFO bl[3]:B bl[2]:B bl[1]:B bl[0]:B blnn[3]:B blnn[2]:B blnn[1]:B blnn[0]:B decnvss:B lyaenbit:I lyal0bl:I lyal0blnn:I nvss:B vcc:I vssx:I wrcolsel[3]:I wrcolsel[2]:I wrcolsel[1]:I wrcolsel[0]:I wrdata:I
*.PININFO wrdatann:I
Mnlyaen cmm lyaenbit vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnwrcolsel[3] lyacolselnn[3] wrcolsel_rep[3] cmm vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnwrcolsel[2] lyacolselnn[2] wrcolsel_rep[2] cmm vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnwrcolsel[1] lyacolselnn[1] wrcolsel_rep[1] cmm vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnwrcolsel[0] lyacolselnn[0] wrcolsel_rep[0] cmm vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnlyapgnn[3] blnn[3] lyacolsel[3] lyal0blnn vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mnlyapgnn[2] blnn[2] lyacolsel[2] lyal0blnn vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mnlyapgnn[1] blnn[1] lyacolsel[1] lyal0blnn vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mnlyapgnn[0] blnn[0] lyacolsel[0] lyal0blnn vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mn0sel[3] wrbl[3] wrcolselnn[3] decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mn0sel[2] wrbl[2] wrcolselnn[2] decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mn0sel[1] wrbl[1] wrcolselnn[1] decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mn0sel[0] wrbl[0] wrcolselnn[0] decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Miywinvn[3] wrcolselnn[3] wrcolsel[3] vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Miywinvn[2] wrcolselnn[2] wrcolsel[2] vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Miywinvn[1] wrcolselnn[1] wrcolsel[1] vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Miywinvn[0] wrcolselnn[0] wrcolsel[0] vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Miwrblnn[3] blnn[3] wrblnn[3] nvss vssx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
Miwrblnn[2] blnn[2] wrblnn[2] nvss vssx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
Miwrblnn[1] blnn[1] wrblnn[1] nvss vssx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
Miwrblnn[0] blnn[0] wrblnn[0] nvss vssx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
Miwrbl[3] bl[3] wrbl[3] nvss vssx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
Miwrbl[2] bl[2] wrbl[2] nvss vssx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
Miwrbl[1] bl[1] wrbl[1] nvss vssx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
Miwrbl[0] bl[0] wrbl[0] nvss vssx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
Mnwrnn[3] wrblnn[3] wrdatann decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnwrnn[2] wrblnn[2] wrdatann decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnwrnn[1] wrblnn[1] wrdatann decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnwrnn[0] wrblnn[0] wrdatann decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnlyapg[3] bl[3] lyacolsel[3] lyal0bl vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mnlyapg[2] bl[2] lyacolsel[2] lyal0bl vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mnlyapg[1] bl[1] lyacolsel[1] lyal0bl vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mnlyapg[0] bl[0] lyacolsel[0] lyal0bl vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mn1sel[3] wrblnn[3] wrcolselnn[3] decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mn1sel[2] wrblnn[2] wrcolselnn[2] decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mn1sel[1] wrblnn[1] wrcolselnn[1] decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mn1sel[0] wrblnn[0] wrcolselnn[0] decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnwr[3] wrbl[3] wrdata decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnwr[2] wrbl[2] wrdata decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnwr[1] wrbl[1] wrdata decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mnwr[0] wrbl[0] wrdata decnvss vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mplyapgnn[3] blnn[3] lyacolselnn[3] lyal0blnn vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mplyapgnn[2] blnn[2] lyacolselnn[2] lyal0blnn vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mplyapgnn[1] blnn[1] lyacolselnn[1] lyal0blnn vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mplyapgnn[0] blnn[0] lyacolselnn[0] lyal0blnn vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mplyaen[3] lyacolselnn[3] lyaenbit vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mplyaen[2] lyacolselnn[2] lyaenbit vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mplyaen[1] lyacolselnn[1] lyaenbit vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mplyaen[0] lyacolselnn[0] lyaenbit vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mpwrcolsel[3] lyacolselnn[3] wrcolsel_rep[3] vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mpwrcolsel[2] lyacolselnn[2] wrcolsel_rep[2] vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mpwrcolsel[1] lyacolselnn[1] wrcolsel_rep[1] vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mpwrcolsel[0] lyacolselnn[0] wrcolsel_rep[0] vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mpwrdbl n1bl wrdata vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mpwrdnnblnn n1blnn wrdatann vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mpwrbl[3] bl[3] wrcolselnn[3] n0bl vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mpwrbl[2] bl[2] wrcolselnn[2] n0bl vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mpwrbl[1] bl[1] wrcolselnn[1] n0bl vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mpwrbl[0] bl[0] wrcolselnn[0] n0bl vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mpwrdnnbl n0bl wrdatann vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mpwrblnn[3] blnn[3] wrcolselnn[3] n0blnn vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mpwrblnn[2] blnn[2] wrcolselnn[2] n0blnn vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mpwrblnn[1] blnn[1] wrcolselnn[1] n0blnn vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mpwrblnn[0] blnn[0] wrcolselnn[0] n0blnn vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mpwrdblnn n0blnn wrdata vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mp1sel[3] wrblnn[3] wrcolselnn[3] n1blnn vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mp1sel[2] wrblnn[2] wrcolselnn[2] n1blnn vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mp1sel[1] wrblnn[1] wrcolselnn[1] n1blnn vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mp1sel[0] wrblnn[0] wrcolselnn[0] n1blnn vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mp0sel[3] wrbl[3] wrcolselnn[3] n1bl vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mp0sel[2] wrbl[2] wrcolselnn[2] n1bl vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mp0sel[1] wrbl[1] wrcolselnn[1] n1bl vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mp0sel[0] wrbl[0] wrcolselnn[0] n1bl vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mplyapg[3] bl[3] lyacolselnn[3] lyal0bl vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mplyapg[2] bl[2] lyacolselnn[2] lyal0bl vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mplyapg[1] bl[1] lyacolselnn[1] lyal0bl vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mplyapg[0] bl[0] lyacolselnn[0] lyal0bl vcc phpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Miywinvp[3] wrcolselnn[3] wrcolsel[3] vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Miywinvp[2] wrcolselnn[2] wrcolsel[2] vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Miywinvp[1] wrcolselnn[1] wrcolsel[1] vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Miywinvp[0] wrcolselnn[0] wrcolsel[0] vcc vcc phpalvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Xilyacolsel[3] lyacolselnn[3] lyacolsel[3] vcc decnvss inv_pcell_issahccsiocm4lya_8007251406475222723
Xilyacolsel[2] lyacolselnn[2] lyacolsel[2] vcc decnvss inv_pcell_issahccsiocm4lya_8007251406475222723
Xilyacolsel[1] lyacolselnn[1] lyacolsel[1] vcc decnvss inv_pcell_issahccsiocm4lya_8007251406475222723
Xilyacolsel[0] lyacolselnn[0] lyacolsel[0] vcc decnvss inv_pcell_issahccsiocm4lya_8007251406475222723
Xiwrcolsel[3] wrcolselnn[3] wrcolsel_rep[3] vcc vssx inv_pcell_issahccsiocm4lya_8007251406475222723
Xiwrcolsel[2] wrcolselnn[2] wrcolsel_rep[2] vcc vssx inv_pcell_issahccsiocm4lya_8007251406475222723
Xiwrcolsel[1] wrcolselnn[1] wrcolsel_rep[1] vcc vssx inv_pcell_issahccsiocm4lya_8007251406475222723
Xiwrcolsel[0] wrcolselnn[0] wrcolsel_rep[0] vcc vssx inv_pcell_issahccsiocm4lya_8007251406475222723
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahcclyal2mux
* View Name:    schematic
************************************************************************
.SUBCKT issahcclyal2mux lyal1bl lyal1blnn lyal2bl lyal2blnn lyasel vcc vssx
*.PININFO lyal1bl:O lyal1blnn:O lyal2bl:I lyal2blnn:I lyasel:I vcc:I vssx:I
Mnlyapg0nn lyal1blnn lyasel lyal2blnn vssx nhpasvt W=3.0 L=14n M=16 LVSEXACTMATCH=0
Mnlyapg0 lyal1bl lyasel lyal2bl vssx nhpasvt W=3.0 L=14n M=16 LVSEXACTMATCH=0
Mplyapg0nn lyal1blnn lyaselnn lyal2blnn vcc phpasvt W=3.0 L=14n M=16 LVSEXACTMATCH=0
Mplyapg0 lyal1bl lyaselnn lyal2bl vcc phpasvt W=3.0 L=14n M=16 LVSEXACTMATCH=0
Xilyasel lyasel lyaselnn vcc vssx inv_pcell_issahcclyal2mux_14186317100302189950
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahcclyal1muxn2n
* View Name:    schematic
************************************************************************
.SUBCKT issahcclyal1muxn2n lyaen lyal0bl lyal0blnn lyal1bl lyal1blnn vcc vssx wrdata1l
*.PININFO lyaen:I lyal0bl:O lyal0blnn:O lyal1bl:I lyal1blnn:I vcc:I vssx:I wrdata1l:I
Xilyanand wrdata1l lyaen lyaselnn vcc vssx na2_pcell_issahcclyal1muxn2n_15548040510760993482
Mnlyapg0 lyal0bl lyasel lyal1bl vssx nhpasvt W=3.0 L=14n M=16 LVSEXACTMATCH=0
Mnlyapg0nn lyal0blnn lyasel lyal1blnn vssx nhpasvt W=3.0 L=14n M=16 LVSEXACTMATCH=0
Xilyasel lyaselnn lyasel vcc vssx inv_pcell_issahcclyal1muxn2n_8007251406475222723
Mplyapg0nn lyal0blnn lyaselnn lyal1blnn vcc phpasvt W=3.0 L=14n M=16 LVSEXACTMATCH=0
Mplyapg0 lyal0bl lyaselnn lyal1bl vcc phpasvt W=3.0 L=14n M=16 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahcciowrbfnbl
* View Name:    schematic
************************************************************************
.SUBCKT issahcciowrbfnbl decnvss idin lyaenbit lyaennn nbl_kicknn ncg2 nvss vcc vssx
+ waenn[2] waenn[1] waenn[0] wrclk wrdata wrdatann wren
*.PININFO decnvss:O idin:I lyaenbit:O lyaennn:I nbl_kicknn:I ncg2:O nvss:O vcc:I vssx:I waenn[2]:I waenn[1]:I waenn[0]:I wrclk:I wrdata:O wrdatann:O wren:I
Xwanor[2] kicknn waenn[2] kick[2] vcc vssx no2_pcell_issahccciocm4_15548040510760993482
Xwanor[1] kicknn waenn[1] kick[1] vcc vssx no2_pcell_issahccciocm4_15548040510760993482
Xwanor[0] kicknn waenn[0] kick[0] vcc vssx no2_pcell_issahccciocm4_15548040510760993482
Xinor nbl_kick wrenn cnvss vcc vssx no2_pcell_issahccciocm4_7500890791422185133
Xilyaenbit lyaennn nk1 lyaenbit vcc vssx no2_pcell_issahccciocm4_15548040510760993482
Xifb wrclk_int wrclknn nk2 nk1 vcc vssx td_pcell_issahccciocm4_146937493879050003
Mmpcap[1] ncg1 nvss ncg1 vcc phpalvt W=3.0 L=14n M=26 LVSEXACTMATCH=0
Mmpcap[0] ncg0 nvss ncg0 vcc phpalvt W=3.0 L=14n M=12 LVSEXACTMATCH=0
Mmpwrenintnn wrdatann wrenint vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mmpnk2 wrdatann wrd vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mmpwrenint wrdata wrenint vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mmpnk1 wrdata nk1 vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mmpwae1 ncg1 kick[1] vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mmpwae0 ncg0 kick[0] vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mmpwae2 ncg2 kick[2] vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Xipg wrdnn nk1 wrclknn wrclk_int vcc vssx xf_pcell_issahccciocm4_1534216117833948629
Xifw nk1 nk2 vcc vssx inv_pcell_issahccciocm4_17870423651273743962
Xiclk wrclk wrclknn vcc vssx inv_pcell_issahccciocm4_17870423651273743962
Xiclk0 wrclknn wrclk_int vcc vssx inv_pcell_issahccciocm4_17870423651273743962
Xkickinv_in nbl_kicknn nbl_kick vcc vssx inv_pcell_issahccciocm4_8007251406475222723
Xiwrenninv wren wrenn vcc vssx inv_pcell_issahccciocm4_8007251406475222723
Xiwrd nk1 wrd vcc vssx inv_pcell_issahccciocm4_17870423651273743962
Xiwreninv wrenn wrenint vcc vssx inv_pcell_issahccciocm4_8007251406475222723
Xikikinv1 nbl_kick kicknn vcc vssx inv_pcell_issahccciocm4_8007251406475222723
Xiddrvnn idin wrdnn vcc vssx inv_pcell_issahccciocm4_17870423651273743962
Mmncap[1] nvss ncg1 nvss vssx nhpalvt W=3.0 L=14n M=38 LVSEXACTMATCH=0
Mmncap[0] nvss ncg0 nvss vssx nhpalvt W=3.0 L=14n M=18 LVSEXACTMATCH=0
Mmnwrenint com wrenint vssx vssx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mmnnk2 wrdatann wrd com vssx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mmnnk1 wrdata nk1 com vssx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mmdiode decnvss nvss nvss vssx nhpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mmnwae1 ncg1 kick[1] vssx vssx nhpasvt W=3.0 L=14n M=8 LVSEXACTMATCH=0
Mmnwae0 ncg0 kick[0] vssx vssx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mmnwae2 ncg2 kick[2] vssx vssx nhpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mmndecvss2 decnvss wrenn vssx vssx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mmndecvss1 decnvss wrenint nvss vssx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mmnvss nvss cnvss vssx vssx nhpasvt W=3.0 L=14n M=12 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahcciosalat
* View Name:    schematic
************************************************************************
.SUBCKT issahcciosalat clknn d o vcc vssx
*.PININFO clknn:I d:I o:O vcc:I vssx:I
Xifw nk1 nk2 vcc vssx inv_pcell_issahccciocm4_8007251406475222723
Xiclk clknn clk vcc vssx inv_pcell_issahccciocm4_17870423651273743962
Xidrv nk2 o vcc vssx inv_pcell_issahccciocm4_9999192332891373312
Xifb clknn clk nk2 nk1 vcc vssx td_pcell_issahccciocm4_16951344510324896
Xipg d nk1 clk clknn vcc vssx xf_pcell_issahccciocm4_6852071075964942753
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahcciosenseampintnbl
* View Name:    schematic
************************************************************************
.SUBCKT issahcciosenseampintnbl clksalatnn dosa dosann inbl inblnn saenn sapchnn
+ vcc vssx
*.PININFO clksalatnn:O dosa:O dosann:O inbl:B inblnn:B saenn:I sapchnn:I vcc:I vssx:I
Mqna sapch sapchnn vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqnb sapch sae vssx vssx nhpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Misae1 com sae vssx vssx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Misae0 com sae vssx vssx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Xsao inblnn dosa vcc vssx inv_pcell_issahccciocm4_8007251406475222723
Xsaonn inbl dosann vcc vssx inv_pcell_issahccciocm4_8007251406475222723
Xsalatinv sae clksalatnn vcc vssx inv_pcell_issahccciocm4_17870423651273743962
Xsapchinv sapch sapchnn_int vcc vssx inv_pcell_issahccciocm4_8007251406475222723
Xsaeinv saenn sae vcc vssx inv_pcell_issahccciocm4_8007251406475222723
Mndmy0 com vssx dmy0_nocon vssx nhpalvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Mndmy1 com vssx dmy1_nocon vssx nhpalvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Misanmosblnn inblnn inbl com vssx nhpalvt W=3.0 L=14n M=16 LVSEXACTMATCH=0
Misanmosbl inbl inblnn com vssx nhpalvt W=3.0 L=14n M=16 LVSEXACTMATCH=0
Mqpb n1 sae sapchnorstk vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mqpa sapch sapchnn n1 vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mpdmy0 inblnn vcc vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Mpdmy1 inbl vcc vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Misapmosblnn inblnn inbl vcc vcc phpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Msapchnorpstk sapchnorstk vssx vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Misapchbl inbl sapchnn_int vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Misapchblnn inblnn sapchnn_int vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Misapmosbl inbl inblnn vcc vcc phpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
Misapcheq inbl sapchnn_int inblnn vcc phpasvt W=3.0 L=14n M=4 LVSEXACTMATCH=0
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5bit
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5bit bl bl_b sramvcc sramvss wl
*.PININFO bl:B bl_b:B sramvcc:I sramvss:I wl:I
Xibit bl bl_b sramvcc sramvss wl x78hcc5bitfe
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5edg
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5edg bl sramvcc sramvss
*.PININFO bl:B sramvcc:I sramvss:I
Xibitedge bl sramvcc sramvss x78hcc5edgfe
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5drvtrk
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5drvtrk bl_nc dbl dwl sramvcc sramvss wlnc
*.PININFO bl_nc:B dbl:B dwl:I sramvcc:I sramvss:I wlnc:I
Xibit bl_nc dbl dwl sramvcc sramvss wlnc x78hcc5trkfe
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5ncntrk
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5ncntrk bl_nc dbl dbl_noconn dwl sramvcc sramvss wlnc
*.PININFO bl_nc:B dbl:B dbl_noconn:I dwl:I sramvcc:I sramvss:I wlnc:I
Xibit bl_nc dbl_noconn dwl sramvcc sramvss wlnc x78hcc5trkfe
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5ldtrk
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5ldtrk bl_nc dbl dwl sramvcc sramvss wlnc
*.PININFO bl_nc:B dbl:B dwl:I sramvcc:I sramvss:I wlnc:I
Xibit bl_nc dbl dwl sramvcc sramvss wlnc x78hcc5trkfe
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_giocntrl activered#[1] activered#[0] bankgrant1h[1]
+ bankgrant1h[0] bankgrant1l[1] bankgrant1l[0] bankgrant2h[1] bankgrant2h[0] clk
+ clkbank clkrdsync_dn clkrdsync_up clkwr2h2l_dn clkwr2h2l_up fz_asynckick fz_asynckick#
+ fz_asyncrd fz_asyncrd# fz_asyncwr fz_asyncwr# fz_clkgate fz_finekick[3] fz_finekick[2]
+ fz_finekick[1] fz_finekick[0] fz_finekick#[3] fz_finekick#[2] fz_finekick#[1]
+ fz_finekick#[0] fz_rassel[2] fz_rassel[1] fz_rassel[0] fz_rassel#[2] fz_rassel#[1]
+ fz_rassel#[0] fz_rdwlcut fz_rdwlcut# fz_rdwlpw[3] fz_rdwlpw[2] fz_rdwlpw[1] fz_rdwlpw[0]
+ fz_rdwlpw#[3] fz_rdwlpw#[2] fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw[1] fz_saepw[0]
+ fz_saepw#[1] fz_saepw#[0] fz_trbwassel[2] fz_trbwassel[1] fz_trbwassel[0] fz_trbwassel#[2]
+ fz_trbwassel#[1] fz_trbwassel#[0] fz_trkwllvl[2] fz_trkwllvl[1] fz_trkwllvl[0]
+ fz_trkwllvl#[2] fz_trkwllvl#[1] fz_trkwllvl#[0] fz_wassel[2] fz_wassel[1] fz_wassel[0]
+ fz_wassel#[2] fz_wassel#[1] fz_wassel#[0] fz_wrwlcut fz_wrwlcut# fz_wrwlpw[1]
+ fz_wrwlpw[0] fz_wrwlpw#[1] fz_wrwlpw#[0] grant ia[8] ia[7] ia[6] ia[5] ia[4] ia[3]
+ ia[2] ia[1] ia[0] ia_hi#[2] ia_hi#[1] ia_hi#[0] ia_mid#[2] ia_mid#[1] ia_mid#[0]
+ ia_wle#[1] ia_wle#[0] irowredun[1] irowredun[0] iway[7] iway[6] iway[5] iway[4]
+ iway[3] iway[2] iway[1] iway[0] iwen iwren1h iwren1l2l iwren2h3h lyabnk lyaclkstop
+ lyaen lyanowl lyanowl# lyaselgio lyaseltmr selbnk0nn_dn selbnk0nn_up selbnk1nn_dn
+ selbnk1nn_up sideen[0] turbomode turbomode# vcc vss wayselbnk[3] wayselbnk[2]
+ wayselbnk[1] wayselbnk[0]
*.PININFO activered#[1]:O activered#[0]:O bankgrant1h[1]:O bankgrant1h[0]:O bankgrant1l[1]:O bankgrant1l[0]:O bankgrant2h[1]:O bankgrant2h[0]:O clk:I clkbank:O clkrdsync_dn:O clkrdsync_up:O clkwr2h2l_dn:O clkwr2h2l_up:O fz_asynckick:I fz_asynckick#:O fz_asyncrd:I fz_asyncrd#:O fz_asyncwr:I fz_asyncwr#:O
*.PININFO fz_clkgate:I fz_finekick[3]:I fz_finekick[2]:I fz_finekick[1]:I fz_finekick[0]:I fz_finekick#[3]:O fz_finekick#[2]:O fz_finekick#[1]:O fz_finekick#[0]:O fz_rassel[2]:I fz_rassel[1]:I fz_rassel[0]:I fz_rassel#[2]:O fz_rassel#[1]:O fz_rassel#[0]:O fz_rdwlcut:I fz_rdwlcut#:O fz_rdwlpw[3]:I fz_rdwlpw[2]:I fz_rdwlpw[1]:I
*.PININFO fz_rdwlpw[0]:I fz_rdwlpw#[3]:O fz_rdwlpw#[2]:O fz_rdwlpw#[1]:O fz_rdwlpw#[0]:O fz_saepw[1]:I fz_saepw[0]:I fz_saepw#[1]:O fz_saepw#[0]:O fz_trbwassel[2]:I fz_trbwassel[1]:I fz_trbwassel[0]:I fz_trbwassel#[2]:O fz_trbwassel#[1]:O fz_trbwassel#[0]:O fz_trkwllvl[2]:I fz_trkwllvl[1]:I fz_trkwllvl[0]:I fz_trkwllvl#[2]:O fz_trkwllvl#[1]:O
*.PININFO fz_trkwllvl#[0]:O fz_wassel[2]:I fz_wassel[1]:I fz_wassel[0]:I fz_wassel#[2]:O fz_wassel#[1]:O fz_wassel#[0]:O fz_wrwlcut:I fz_wrwlcut#:O fz_wrwlpw[1]:I fz_wrwlpw[0]:I fz_wrwlpw#[1]:O fz_wrwlpw#[0]:O grant:I ia[8]:I ia[7]:I ia[6]:I ia[5]:I ia[4]:I ia[3]:I
*.PININFO ia[2]:I ia[1]:I ia[0]:I ia_hi#[2]:O ia_hi#[1]:O ia_hi#[0]:O ia_mid#[2]:O ia_mid#[1]:O ia_mid#[0]:O ia_wle#[1]:O ia_wle#[0]:O irowredun[1]:I irowredun[0]:I iway[7]:I iway[6]:I iway[5]:I iway[4]:I iway[3]:I iway[2]:I iway[1]:I
*.PININFO iway[0]:I iwen:I iwren1h:O iwren1l2l:O iwren2h3h:O lyabnk:I lyaclkstop:I lyaen:I lyanowl:I lyanowl#:O lyaselgio:O lyaseltmr:O selbnk0nn_dn:O selbnk0nn_up:O selbnk1nn_dn:O selbnk1nn_up:O sideen[0]:O turbomode:I turbomode#:O vcc:I
*.PININFO vss:I wayselbnk[3]:O wayselbnk[2]:O wayselbnk[1]:O wayselbnk[0]:O
Xirep5 grant2l grant2l_rep vcc vss i0mbfn000ab1n03x5
Xirep4 grant1l_rep grant1l_rep_rep0 vcc vss i0mbfn000ac1n02x5
Xirep3 clk clk_rep vcc vss i0mcbf000ab1n03x5
Xirep2[1] banksel1l2l[1] banksel1l2l_rep[1] vcc vss i0mbfm201ac1n02x5
Xirep2[0] banksel1l2l[0] banksel1l2l_rep[0] vcc vss i0mbfm201ac1n02x5
Xgnac2 fz_trbwassel[0] vcc vss i0mydp122uc1n00x5
Xgnac0 fz_trbwassel[1] vcc vss i0mydp122uc1n00x5
Xgnac1 irowredun[0] vcc vss i0mydp122ub1n00x5
Xilyaclkstop_cg clk_rep lyaclkstop lyaclkstop_cg vcc vss i0mlsn000ac1n03x5
Xiclkfree0 clk clkfree# clkgate vcc vss i0mclbno2ab1n12x5
Xiclkgate lyaclkstop_cg fz_clkgate clkgate vcc vss i0morn002ac1n02x5
Xiclkbank clkfree# clkbank vcc vss i0mcinv00ab1n24x5
Xiclkfree1 clkfree# clkfree vcc vss i0mcinv00ab1n12x5
Xiclkfree2 clkfree clkfree_del vcc vss i0mbfn000ab1n03x5
Xbankselinv ia[0] banksel1h#[1] vcc vss i0minv000ac1n09x5
Xigrant2h_del grant2h# grant2h_del# vcc vss i0mbfm604ac1n02x5
Xigrant_iso_prot grant2h_del# grant miss grant1h# vcc vss i0mnand03ac1n06x5
Xgrantlatch1l clkfree_del# grant miss grant2h_del# grant1l vcc vss i0mlsnan3ab1n06x5
Xigrant1l# grant1l grant1l# vcc vss i0minv000ac1n06x5
Xgrant1l2lgen clkfree clkgrant1l2l# grant2h vcc vss i0mclbno2ab1n03x5
Xgrant1l2ldrv clkgrant1l2l# clkgrant1l2l vcc vss i0mcinv00ab1n04x5
Xilyaway clkgrant1l2l miss lyaway vcc vss i0mlsn080ac1n02x5
Xilyabnken lyaen lyabnk lyaway lyasel# vcc vss i0mnand03ac1n02x5
Xilyaselgio lyasel# lyaselgio vcc vss i0minv000ac1n12x5
Xilyaseltmr lyasel# lyaseltmr vcc vss i0minv000ac1n12x5
Xilyanowl lyanowl lyanowl# vcc vss i0minv000ac1n12x5
Xgrant2h3hnandgen clkfree clkgrant2h3h# grant1l vcc vss i0mclbna2ab1n03x5
Xgrant2h3hnotgen clkgrant2h3h# clkgrant2h3h vcc vss i0mcinv00ab1n04x5
Xgrantrd2hgen clkgrant2h3h# clkgrantrd2h wren1l2l_rep vcc vss i0mclbno2ab1n03x5
Xgrant1lnanddrv[0] grant1l banksel1l2l[0] bankgrant1l#[0] vcc vss i0mnand02ab1n06x5
Xgrant1linvdrv[0] bankgrant1l#[0] bankgrant1l[0] vcc vss i0minv000ac1n15x5
Xgrant2hnanddrv[0] grant2h banksel2h3h[0] bankgrant2h#[0] vcc vss i0mnand02ac1n03x5
Xgrant2hinvdrv[0] bankgrant2h#[0] bankgrant2h[0] vcc vss i0minv000ac1n15x5
Xgrant1lnanddrv[1] grant1l banksel1l2l[1] bankgrant1l#[1] vcc vss i0mnand02ab1n06x5
Xgrant1linvdrv[1] bankgrant1l#[1] bankgrant1l[1] vcc vss i0minv000ac1n15x5
Xgrant2hnanddrv[1] grant2h banksel2h3h[1] bankgrant2h#[1] vcc vss i0mnand02ac1n03x5
Xgrant2hinvdrv[1] bankgrant2h#[1] bankgrant2h[1] vcc vss i0minv000ac1n15x5
Xgrantlatch2h clkfree_del grant1l_rep_rep grant2h# vcc vss i0mlsn000ac1n03x5
Xgrantlatch2l clkfree grant2h grant2l vcc vss i0mlsn080ac1n03x5
Xgrantlatch3h clkfree grant2l_rep grant3h vcc vss i0mlsn000ac1n03x5
Xbanksellatch1l2l[0] clkgrant1l2l ia[0] banksel1l2l[0] vcc vss i0mlun090ac1n03x5
Xibanksel1l2l_del[0] banksel1l2l_rep[0] banksel1l2l_del[0] vcc vss i0mbfm201ac1n02x5
Xbanksellatch2h3h[0] clkgrant2h3h banksel1l2l_del[0] banksel2h3h[0] vcc vss i0mlsn000ac1n03x5
Xibankselrd2h3h_del[0] bankselrd2h3h[0] bankselrd2h3h_del[0] vcc vss i0mbfm402ac1n02x5
Xbnkselinv[0] bankselrd2h3h_del[0] selbnk#[0] vcc vss i0minv000ac1n12x5
Xbnkseldrv0up selbnk#[0] selbnk0nn_up vcc vss i0mbfn000ac1d42x5
Xbnkseldrv0dn selbnk#[0] selbnk0nn_dn vcc vss i0mbfn000ac1d42x5
Xbankgrant1hdrv[0] grant1h# ia[0] bankgrant1h[0] vcc vss i0mnor002ac1n16x5
Xbanksellatch1l2l[1] clkgrant1l2l banksel1h#[1] banksel1l2l[1] vcc vss i0mlun090ac1n03x5
Xibanksel1l2l_del[1] banksel1l2l_rep[1] banksel1l2l_del[1] vcc vss i0mbfm201ac1n02x5
Xbanksellatch2h3h[1] clkgrant2h3h banksel1l2l_del[1] banksel2h3h[1] vcc vss i0mlsn000ac1n03x5
Xibankselrd2h3h_del[1] bankselrd2h3h[1] bankselrd2h3h_del[1] vcc vss i0mbfm402ac1n02x5
Xbnkselinv[1] bankselrd2h3h_del[1] selbnk#[1] vcc vss i0minv000ac1n12x5
Xbnkseldrv1up selbnk#[1] selbnk1nn_up vcc vss i0mbfn000ac1d42x5
Xbnkseldrv1dn selbnk#[1] selbnk1nn_dn vcc vss i0mbfn000ac1d42x5
Xbankgrant1hdrv[1] grant1h# banksel1h#[1] bankgrant1h[1] vcc vss i0mnor002ac1n16x5
Xiclkwr2h clkfree# clkwr2h grant1l# wren1l2l# vcc vss i0mclbno3ab1n04x5
Xiclkwr2l# clkfree clkwr2l grant2h# iwren2h3h# vcc vss i0mclbno3ab1n04x5
Xiclkwr2h2l clkwr2h clkwr2h_del clkwr2l clkwr2h2l# vcc vss i0mnor003ab1n12x5
Xwren1llatch clkgrant1l2l iwen wren1l2l# vcc vss i0mlun090ab1d06x5
Xwren1hbuf iwen iwren1h vcc vss i0mbfn000ac1n18x5
Xwren2hlatch clkgrant2h3h wren1l2l_rep iwren2h3h_st vcc vss i0mlsn000ac1n03x5
Xwren2hbuf iwren2h3h_st iwren2h3h vcc vss i0mbfn000ac1n12x5
Xwren1lbuf wren1l2l# iwren1l2l vcc vss i0minv000ac1n15x5
Xiwren1l# wren1l2l# wren1l2l vcc vss i0minv000ac1n03x5
Xiclkrd3h clkfree clkrd3h# grant2l wren1l2l# vcc vss i0mclbna3ab1n03x5
Xiwren2h# iwren2h3h_st iwren2h3h# vcc vss i0minv000ac1n03x5
Xirden3h# grant3h iwren2h3h# rden3h# vcc vss i0mnand02ac1n03x5
Xirden3h rden3h# rden3h vcc vss i0minv000ac1n03x5
Xiclkrd3l clkfree# clkrd3l# rden3h vcc vss i0mclbna2ab1n03x5
Xiclkrd3h_del clkrd3h# clkrd3h_del# vcc vss i0mbfm807ab1n03x5
Xiclkrd3h3l clkrd3l# clkrd3h_del# clkrdsync vcc vss i0mnand02ab1n06x5
Xiclkrdsync clkrdsync clkrdsync# vcc vss i0mcinv00ab1n12x5
Xiclkrdsync_up clkrdsync# clkrdsync_up vcc vss i0mcinv00ab1n36x5
Xiclkrdsync_dn clkrdsync# clkrdsync_dn vcc vss i0mcinv00ab1n36x5
Xifz_rassel[2] fz_rassel[2] fz_rassel#[2] vcc vss i0minv000ac1n09x5
Xifz_rassel[1] fz_rassel[1] fz_rassel#[1] vcc vss i0minv000ac1n09x5
Xifz_rassel[0] fz_rassel[0] fz_rassel#[0] vcc vss i0minv000ac1n09x5
Xifz_rdwlcut fz_rdwlcut fz_rdwlcut# vcc vss i0minv000ac1n09x5
Xifz_wrwlcut fz_wrwlcut fz_wrwlcut# vcc vss i0minv000ac1n09x5
Xifz_asyncrd fz_asyncrd fz_asyncrd# vcc vss i0minv000ac1n09x5
Xifz_rdwlpw[3] fz_rdwlpw[3] fz_rdwlpw#[3] vcc vss i0minv000ac1n09x5
Xifz_rdwlpw[2] fz_rdwlpw[2] fz_rdwlpw#[2] vcc vss i0minv000ac1n09x5
Xifz_rdwlpw[1] fz_rdwlpw[1] fz_rdwlpw#[1] vcc vss i0minv000ac1n09x5
Xifz_rdwlpw[0] fz_rdwlpw[0] fz_rdwlpw#[0] vcc vss i0minv000ac1n09x5
Xifz_saepw[1] fz_saepw[1] fz_saepw#[1] vcc vss i0minv000ac1n09x5
Xifz_saepw[0] fz_saepw[0] fz_saepw#[0] vcc vss i0minv000ac1n09x5
Xifz_trkwllvl[2] fz_trkwllvl[2] fz_trkwllvl#[2] vcc vss i0minv000ac1n09x5
Xifz_trkwllvl[1] fz_trkwllvl[1] fz_trkwllvl#[1] vcc vss i0minv000ac1n09x5
Xifz_trkwllvl[0] fz_trkwllvl[0] fz_trkwllvl#[0] vcc vss i0minv000ac1n09x5
Xifz_asyncwr fz_asyncwr fz_asyncwr# vcc vss i0minv000ac1n09x5
Xifz_wrwlpw[1] fz_wrwlpw[1] fz_wrwlpw#[1] vcc vss i0minv000ac1n09x5
Xifz_wrwlpw[0] fz_wrwlpw[0] fz_wrwlpw#[0] vcc vss i0minv000ac1n09x5
Xifz_wassel[2] fz_wassel[2] fz_wassel#[2] vcc vss i0minv000ac1n09x5
Xifz_wassel[1] fz_wassel[1] fz_wassel#[1] vcc vss i0minv000ac1n09x5
Xifz_wassel[0] fz_wassel[0] fz_wassel#[0] vcc vss i0minv000ac1n09x5
Xifz_finekick[3] fz_finekick[3] fz_finekick#[3] vcc vss i0minv000ac1n09x5
Xifz_finekick[2] fz_finekick[2] fz_finekick#[2] vcc vss i0minv000ac1n09x5
Xifz_finekick[1] fz_finekick[1] fz_finekick#[1] vcc vss i0minv000ac1n09x5
Xifz_finekick[0] fz_finekick[0] fz_finekick#[0] vcc vss i0minv000ac1n09x5
Xiturbomode turbomode turbomode# vcc vss i0minv000ac1n15x5
Xifz_trbwassel[2] fz_trbwassel[2] fz_trbwassel#[2] vcc vss i0minv000ac1n09x5
Xifz_trbwassel[1] fz_trbwassel[1] fz_trbwassel#[1] vcc vss i0minv000ac1n09x5
Xifz_trbwassel[0] fz_trbwassel[0] fz_trbwassel#[0] vcc vss i0minv000ac1n09x5
Xifz_asynckick fz_asynckick fz_asynckick# vcc vss i0minv000ac1n09x5
Xclkwr2hdrv_up clkwr2h2l# clkwr2h2l_up vcc vss i0mcinv00ab1n36x5
Xclkwr2hdrv_dn clkwr2h2l# clkwr2h2l_dn vcc vss i0mcinv00ab1n36x5
Xiahidrv[2] ia[8] ia_hi#[2] vcc vss i0minv000ab1n15x5
Xiahidrv[1] ia[7] ia_hi#[1] vcc vss i0minv000ab1n15x5
Xiahidrv[0] ia[6] ia_hi#[0] vcc vss i0minv000ab1n15x5
Xiamiddrv[2] ia[5] ia_mid#[2] vcc vss i0minv000ab1n15x5
Xiamiddrv[1] ia[4] ia_mid#[1] vcc vss i0minv000ab1n15x5
Xiamiddrv[0] ia[3] ia_mid#[0] vcc vss i0minv000ab1n15x5
Xiawledrv[1] ia[2] ia_wle#[1] vcc vss i0minv000ab1n15x5
Xiawledrv[0] ia[1] ia_wle#[0] vcc vss i0minv000ab1n15x5
Xiaysel#[3] iway[3] iway[7] wayselbnk#[3] vcc vss i0mnor002ac1n06x5
Xiaysel#[2] iway[2] iway[6] wayselbnk#[2] vcc vss i0mnor002ac1n06x5
Xiaysel#[1] iway[1] iway[5] wayselbnk#[1] vcc vss i0mnor002ac1n06x5
Xiaysel#[0] iway[0] iway[4] wayselbnk#[0] vcc vss i0mnor002ac1n06x5
Xiaysel[3] wayselbnk#[3] wayselbnk[3] vcc vss i0minv000ac1n15x5
Xiaysel[2] wayselbnk#[2] wayselbnk[2] vcc vss i0minv000ac1n15x5
Xiaysel[1] wayselbnk#[1] wayselbnk[1] vcc vss i0minv000ac1n15x5
Xiaysel[0] wayselbnk#[0] wayselbnk[0] vcc vss i0minv000ac1n15x5
Xiirowredun[1] irowredun[1] activered#[1] vcc vss i0minv000ac1n15x5
Xiirowredun[0] irowredun[0] activered#[0] vcc vss i0minv000ac1n15x5
Xignac_fz_asynckick fz_asynckick vcc vss i0mydp122ub1n00x5
Xignac_fz_trbwassel[2] fz_trbwassel[2] vcc vss i0mydp122ub1n00x5
Xignac_turbomode turbomode vcc vss i0mydp122ub1n00x5
Xignac_fz_finekick[0] fz_finekick[0] vcc vss i0mydp122ub1n00x5
Xignac_fz_finekick[1] fz_finekick[1] vcc vss i0mydp122ub1n00x5
Xignac_fz_finekick[2] fz_finekick[2] vcc vss i0mydp122ub1n00x5
Xignac_fz_finekick[3] fz_finekick[3] vcc vss i0mydp122ub1n00x5
Xignac_fz_wassel[0] fz_wassel[0] vcc vss i0mydp122ub1n00x5
Xignac_fz_wassel[1] fz_wassel[1] vcc vss i0mydp122ub1n00x5
Xignac_fz_wassel[2] fz_wassel[2] vcc vss i0mydp122ub1n00x5
Xignac_fz_wrwlpw[0] fz_wrwlpw[0] vcc vss i0mydp122ub1n00x5
Xignac_fz_wrwlpw[1] fz_wrwlpw[1] vcc vss i0mydp122ub1n00x5
Xignac_fz_asyncwr fz_asyncwr vcc vss i0mydp122ub1n00x5
Xignac_fz_trkwllvl[0] fz_trkwllvl[0] vcc vss i0mydp122ub1n00x5
Xignac_fz_trkwllvl[1] fz_trkwllvl[1] vcc vss i0mydp122ub1n00x5
Xignac_fz_trkwllvl[2] fz_trkwllvl[2] vcc vss i0mydp122ub1n00x5
Xignac_fz_saepw[0] fz_saepw[0] vcc vss i0mydp122ub1n00x5
Xignac_fz_rdwlpw[0] fz_rdwlpw[0] vcc vss i0mydp122ub1n00x5
Xignac_fz_rdwlpw[1] fz_rdwlpw[1] vcc vss i0mydp122ub1n00x5
Xignac_fz_rdwlpw[2] fz_rdwlpw[2] vcc vss i0mydp122ub1n00x5
Xignac_fz_rdwlpw[3] fz_rdwlpw[3] vcc vss i0mydp122ub1n00x5
Xignac_fz_asyncrd fz_asyncrd vcc vss i0mydp122ub1n00x5
Xignac_fz_wrwlcut fz_wrwlcut vcc vss i0mydp122ub1n00x5
Xignac_fz_rdwlcut fz_rdwlcut vcc vss i0mydp122ub1n00x5
Xignac_fz_rassel[0] fz_rassel[0] vcc vss i0mydp122ub1n00x5
Xignac_fz_rassel[1] fz_rassel[1] vcc vss i0mydp122ub1n00x5
Xignac_fz_rassel[2] fz_rassel[2] vcc vss i0mydp122ub1n00x5
Xignac_fz_clkgate fz_clkgate vcc vss i0mydp122uc1n00x5
Xignac_lyaen lyaen vcc vss i0mydp122ub1n00x5
Xignac_lyaclkstop lyaclkstop vcc vss i0mydp122ub1n00x5
Xignac_lyabnk lyabnk vcc vss i0mydp122ub1n00x5
Xignac_iway[0] iway[0] vcc vss i0mydp122ub1n00x5
Xignac_iway[1] iway[1] vcc vss i0mydp122ub1n00x5
Xignac_iway[2] iway[2] vcc vss i0mydp122ub1n00x5
Xignac_iway[3] iway[3] vcc vss i0mydp122ub1n00x5
Xignac_iway[4] iway[4] vcc vss i0mydp122ub1n00x5
Xignac_iway[5] iway[5] vcc vss i0mydp122ub1n00x5
Xignac_iway[6] iway[6] vcc vss i0mydp122ub1n00x5
Xignac_iway[7] iway[7] vcc vss i0mydp122ub1n00x5
Xignac_irowredun[1] irowredun[1] vcc vss i0mydp122ub1n00x5
Xignac_iwen iwen vcc vss i0mydp122ub1n00x5
Xignac_grant grant vcc vss i0mydp122ub1n00x5
Xignac_ia[0] ia[0] vcc vss i0mydp122ub1n00x5
Xignac_ia[1] ia[1] vcc vss i0mydp122ub1n00x5
Xignac_ia[2] ia[2] vcc vss i0mydp122ub1n00x5
Xignac_ia[3] ia[3] vcc vss i0mydp122ub1n00x5
Xignac_ia[4] ia[4] vcc vss i0mydp122ub1n00x5
Xignac_ia[5] ia[5] vcc vss i0mydp122ub1n00x5
Xignac_ia[6] ia[6] vcc vss i0mydp122ub1n00x5
Xignac_ia[7] ia[7] vcc vss i0mydp122ub1n00x5
Xignac_ia[8] ia[8] vcc vss i0mydp122ub1n00x5
Xignac_clk clk vcc vss i0mydp122ub1n00x5
Ximiss wayselbnk#[0] wayselbnk#[1] wayselbnk#[2] wayselbnk#[3] miss vcc vss i0mnand04ac1n06x5
Xisideaddr sideen0# sideen1# sideen[0] vcc vss i0mnand02ac1n16x5
Xisideen0 iway[0] iway[1] sideen0# vcc vss i0mnor042ac1n03x5
Xisideen1 iway[2] iway[3] sideen1# vcc vss i0mnor042ac1n03x5
Xiwrclk_del clkwr2h clkwr2h_del vcc vss i0mbfm605ac1n03x5
Xgrant2hinv grant2h# grant2h vcc vss i0minv000ab1n03x5
Xibanksel1h[0] ia[0] banksel1h[0] vcc vss i0minv000ac1n06x5
Xibanksel1h[1] banksel1h#[1] banksel1h[1] vcc vss i0minv000ac1n06x5
Xibankselrd2h3h[0] clkgrantrd2h banksel1h[0] bankselrd2h3h[0] vcc vss i0mfhn000ac1d02x5
Xibankselrd2h3h[1] clkgrantrd2h banksel1h[1] bankselrd2h3h[1] vcc vss i0mfhn000ac1d02x5
Xiclkfree3 clkfree# clkfree_del# vcc vss i0mbfm201ab1n03x5
Xirep grant1l grant1l_rep vcc vss i0mbfn000ac1n02x5
Xirep0 wren1l2l wren1l2l_rep vcc vss i0mbfm201ac1n03x5
Xirep1 grant1l_rep_rep0 grant1l_rep_rep vcc vss i0minv000ab1n03x5
Xgnac3 lyanowl vcc vss i0mydp122uc1n00x5
Xgnac4 fz_saepw[1] vcc vss i0mydp122ub1n00x5
Xip78d6hcf2sr4096x135m4i2k4w8r2lya_giocntrl_dcap_container vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_giocntrl_dcap_container
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issax2decred
* View Name:    schematic
************************************************************************
.SUBCKT issax2decred c6saveb c6savet decvccb decvcct slpenb slpent vcc vssx wlb[1]
+ wlb[0] wlered[1] wlered[0] wllvlnnb[2] wllvlnnb[1] wllvlnnb[0] wllvlnnt[2] wllvlnnt[1]
+ wllvlnnt[0] wlt[1] wlt[0]
*.PININFO c6saveb:I c6savet:I decvccb:B decvcct:B slpenb:I slpent:I vcc:I vssx:I wlb[1]:O wlb[0]:O wlered[1]:I wlered[0]:I wllvlnnb[2]:I wllvlnnb[1]:I wllvlnnb[0]:I wllvlnnt[2]:I wllvlnnt[1]:I wllvlnnt[0]:I wlt[1]:O wlt[0]:O
Xxdec20b c6saveb decvccb slpenb vcc vssx wlb[1] wlb[0] wllvlnnb[2] wllvlnnb[1] wllvlnnb[0]
+ wlnn[1] wlnn[0] issax2dec2
Xxdec20t c6savet decvcct slpent vcc vssx wlt[1] wlt[0] wllvlnnt[2] wllvlnnt[1] wllvlnnt[0]
+ wlnn[1] wlnn[0] issax2dec2
Xxdecredwleinv vcc vssx wlered[1] wlered[0] wlnn[1] wlnn[0] issax2decredwleinv
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issax2dec4
* View Name:    schematic
************************************************************************
.SUBCKT issax2dec4 c6saveb c6savet decvccb decvcct shclkb[3] shclkb[2] shclkb[1]
+ shclkb[0] shclkt[3] shclkt[2] shclkt[1] shclkt[0] slpenb slpent vcc vssx wlb[3]
+ wlb[2] wlb[1] wlb[0] wleb[3] wleb[2] wleb[1] wleb[0] wlet[3] wlet[2] wlet[1] wlet[0]
+ wllvlnnb[2] wllvlnnb[1] wllvlnnb[0] wllvlnnt[2] wllvlnnt[1] wllvlnnt[0] wlt[3]
+ wlt[2] wlt[1] wlt[0] xpredechi xpredecmid
*.PININFO c6saveb:I c6savet:I decvccb:B decvcct:B shclkb[3]:B shclkb[2]:B shclkb[1]:B shclkb[0]:B shclkt[3]:B shclkt[2]:B shclkt[1]:B shclkt[0]:B slpenb:I slpent:I vcc:I vssx:I wlb[3]:O wlb[2]:O wlb[1]:O wlb[0]:O
*.PININFO wleb[3]:I wleb[2]:I wleb[1]:I wleb[0]:I wlet[3]:I wlet[2]:I wlet[1]:I wlet[0]:I wllvlnnb[2]:I wllvlnnb[1]:I wllvlnnb[0]:I wllvlnnt[2]:I wllvlnnt[1]:I wllvlnnt[0]:I wlt[3]:O wlt[2]:O wlt[1]:O wlt[0]:O xpredechi:I xpredecmid:I
Xxdecnandb ab shclkb[3] shclkb[2] shclkb[1] shclkb[0] vcc vssx wleb[3] wleb[2] wleb[1]
+ wleb[0] wlnnb[3] wlnnb[2] wlnnb[1] wlnnb[0] issax2nand4
Xxdecnandt ab shclkt[3] shclkt[2] shclkt[1] shclkt[0] vcc vssx wlet[3] wlet[2] wlet[1]
+ wlet[0] wlnnt[3] wlnnt[2] wlnnt[1] wlnnt[0] issax2nand4
Xxdecpre1 ab vcc vssx xpredechi xpredecmid issaxdecpre
Xxdec20b c6saveb decvccb slpenb vcc vssx wlb[1] wlb[0] wllvlnnb[2] wllvlnnb[1] wllvlnnb[0]
+ wlnnb[1] wlnnb[0] issax2dec2
Xxdec20t c6savet decvcct slpent vcc vssx wlt[1] wlt[0] wllvlnnt[2] wllvlnnt[1] wllvlnnt[0]
+ wlnnt[1] wlnnt[0] issax2dec2
Xxdec21b c6saveb decvccb slpenb vcc vssx wlb[3] wlb[2] wllvlnnb[2] wllvlnnb[1] wllvlnnb[0]
+ wlnnb[3] wlnnb[2] issax2dec2
Xxdec21t c6savet decvcct slpent vcc vssx wlt[3] wlt[2] wllvlnnt[2] wllvlnnt[1] wllvlnnt[0]
+ wlnnt[3] wlnnt[2] issax2dec2
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice clkrdsync clkwr2h2l idin0 idin1l0
+ lyal0bl0 lyal0blnn0 lyal1bl lyal1blnn lyasel odout0 rddataout0_0 rddataout0_1
+ selbnk0nn selbnk1nn vcc vss
*.PININFO clkrdsync:I clkwr2h2l:I idin0:I idin1l0:O lyal0bl0:O lyal0blnn0:O lyal1bl:I lyal1blnn:I lyasel:I odout0:O rddataout0_0:I rddataout0_1:I selbnk0nn:I selbnk1nn:I vcc:I vss:I
Xip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice_dcap_container vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice_dcap_container
Xignac_idin0 idin0 vcc vss issaulohcydp122ab1n00x5
Xwrdatdrv0 wrdata1l0 idin1l0 vcc vss issaubfnb00ac1n24x5
Xwrdatlatch0 clkwr2h2l idin0 wrdata1l0 vcc vss issaulsn080ac1d03x5
Xilyamux0 lyasel lyal0bl0 lyal0blnn0 lyal1bl lyal1blnn vcc vss wrdata1l0 issahcclyal1muxn2n
Xrdsynclatch0 clkrdsync rddataout0_0 rddataout0_1 odout0 selbnk0nn selbnk1nn vcc
+ vss issaulao4ac1d18x5
Xiissaulodcf33ub1n04x5 vcc vss issaulodcf33ub1n04x5
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issastsaegen
* View Name:    schematic
************************************************************************
.SUBCKT issastsaegen asyncsae clkbank clksaemx rden2hnn rden2l rdwlcut saepw[1] saepw[0]
+ syncsae vcc vssx wlclkmx
*.PININFO asyncsae:I clkbank:I clksaemx:O rden2hnn:I rden2l:I rdwlcut:I saepw[1]:I saepw[0]:I syncsae:I vcc:I vssx:I wlclkmx:I
Xirdwlcutpg clksae2lnn tgo sel_rdwlcut sel_rdwlcutnn vcc vssx xf_pcell_issastsaegen_9674134077769332126
Xim2pg1 n1 tgo2 saepw[1] saepwb[1] vcc vssx xf_pcell_issastsaegen_4417371271697137569
Xim1pg0 n4 tgo1 saepwb[0] saepw[0] vcc vssx xf_pcell_issastsaegen_4417371271697137569
Xim1pg1 n3 tgo1 saepw[0] saepwb[0] vcc vssx xf_pcell_issastsaegen_4417371271697137569
Xim2pg0 n0 tgo2 saepwb[1] saepw[1] vcc vssx xf_pcell_issastsaegen_4417371271697137569
Xistpg saenn tgo asyncsae syncsae vcc vssx xf_pcell_issastsaegen_9674134077769332126
Xisyncpg clksae3hnn tgo sel_syncsae sel_syncsaenn vcc vssx xf_pcell_issastsaegen_9674134077769332126
Xifz_invsync sel_syncsae sel_syncsaenn vcc vssx inv_pcell_issastsaegen_8007251406475222723
Xifz_invrdwlcut sel_rdwlcutnn sel_rdwlcut vcc vssx inv_pcell_issastsaegen_8007251406475222723
Xisae2ldrv clksae2l clksae2lnn vcc vssx inv_pcell_issastsaegen_2751921099722748717
Xim1i0 tgo2 n4 vcc vssx inv_pcell_issastsaegen_558738775049825629
Xim1i1 n2 n3 vcc vssx inv_pcell_issastsaegen_558738775049825629
Xisaenn sae saenn vcc vssx inv_pcell_issastsaegen_2751921099722748717
Xisaepw[1] saepw[1] saepwb[1] vcc vssx inv_pcell_issastsaegen_17870423651273743962
Xisaepw[0] saepw[0] saepwb[0] vcc vssx inv_pcell_issastsaegen_17870423651273743962
Xclksaedrv tgo clksaemx vcc vssx inv_pcell_issastsaegen_12598931333203620298
Xdb1 n0 n1a vcc vssx issabfm400ab1d02x5
Xdb2 n1a n1 vcc vssx issabfm400ab1d02x5
Xda tgo2 n2 vcc vssx issabfm400ab1d02x5
Xifz_nardwlcut rdwlcut syncsae sel_rdwlcutnn vcc vssx na2_pcell_issastsaegen_15548040510760993482
Xisaenand clkbank rden2l clksae3hnn vcc vssx na2_pcell_issastsaegen_15109281701568532595
Xide saenn n0 vcc vssx issabfm806ab1d02x5
Xisaerdl sae wlclkmx tgo1 vcc vssx issasaerdl
Xirdwlcutnor clkbank rden2hnn clksae2l vcc vssx no2_pcell_issastsaegen_4654196017136894227
Xifz_norsync rdwlcut asyncsae sel_syncsae vcc vssx no2_pcell_issastsaegen_15548040510760993482
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issafinedl
* View Name:    schematic
************************************************************************
.SUBCKT issafinedl defval in out s[3] s[2] s[1] s[0] vcc vssx
*.PININFO defval:I in:I out:O s[3]:I s[2]:I s[1]:I s[0]:I vcc:I vssx:I
Xi[4] defval NF[3] s[3] sb[3] NB[3] vcc vssx issalastfinemux
XI[1] NB[1] NF[0] s[0] sb[0] out NF[1] vcc vssx issafinemux
XI[2] NB[2] NF[1] s[1] sb[1] NB[1] NF[2] vcc vssx issafinemux
XI[3] NB[3] NF[2] s[2] sb[2] NB[2] NF[3] vcc vssx issafinemux
XIS[3] s[3] sb[3] vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
XIS[2] s[2] sb[2] vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
XIS[1] s[1] sb[1] vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
XIS[0] s[0] sb[0] vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
XI[0] in NF[0] vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccsiocm4lya
* View Name:    schematic
************************************************************************
.SUBCKT issahccsiocm4lya bl[3] bl[2] bl[1] bl[0] blnn[3] blnn[2] blnn[1] blnn[0]
+ decnvss inbl inblnn lyaenbit lyal0bl lyal0blnn nvss pcnn rdcolsel[3] rdcolsel[2]
+ rdcolsel[1] rdcolsel[0] vcc vssx wrcolsel[3] wrcolsel[2] wrcolsel[1] wrcolsel[0]
+ wrdata wrdatann
*.PININFO bl[3]:B bl[2]:B bl[1]:B bl[0]:B blnn[3]:B blnn[2]:B blnn[1]:B blnn[0]:B decnvss:B inbl:B inblnn:B lyaenbit:I lyal0bl:I lyal0blnn:I nvss:B pcnn:I rdcolsel[3]:I rdcolsel[2]:I rdcolsel[1]:I rdcolsel[0]:I
*.PININFO vcc:I vssx:I wrcolsel[3]:I wrcolsel[2]:I wrcolsel[1]:I wrcolsel[0]:I wrdata:I wrdatann:I
Xreadmux bl[3] bl[2] bl[1] bl[0] blnn[3] blnn[2] blnn[1] blnn[0] inbl inblnn rdcolsel[3]
+ rdcolsel[2] rdcolsel[1] rdcolsel[0] vcc vssx issahcciordyselx4
Xblpch bl[3] bl[2] bl[1] bl[0] blnn[3] blnn[2] blnn[1] blnn[0] pcnn vcc vssx issahccioblpch4
Xwritemux bl[3] bl[2] bl[1] bl[0] blnn[3] blnn[2] blnn[1] blnn[0] decnvss lyaenbit
+ lyal0bl lyal0blnn nvss vcc vssx wrcolsel[3] wrcolsel[2] wrcolsel[1] wrcolsel[0]
+ wrdata wrdatann issahcciowryselx4lya
Minblnndmy[0] inblnn vcc vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Minblnndmy[1] inblnn vcc vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Minblnndmy[2] inblnn vcc vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Minblnndmy[3] inblnn vcc vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Minbldmy[0] inbl vcc vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Minbldmy[1] inbl vcc vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Minbldmy[2] inbl vcc vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Minbldmy[3] inbl vcc vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_trkgioslc lyal1bl lyal1blnn lyal2bl lyal2blnn
+ lyasel vcc vss
*.PININFO lyal1bl:O lyal1blnn:O lyal2bl:I lyal2blnn:I lyasel:I vcc:I vss:I
Xilyamux lyal1bl lyal1blnn lyal2bl lyal2blnn lyasel vcc vss issahcclyal2mux
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahcciosenseampnbl
* View Name:    schematic
************************************************************************
.SUBCKT issahcciosenseampnbl inbl inblnn odout saenn sapchnn vcc vssx
*.PININFO inbl:B inblnn:B odout:O saenn:I sapchnn:I vcc:I vssx:I
Xisamp clksatalnn dosa dosann_nocon inbl inblnn saenn sapchnn vcc vssx issahcciosenseampintnbl
Xisalat clksatalnn dosa odout vcc vssx issahcciosalat
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5bit2x1
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5bit2x1 bl bl_b sramvcc sramvss wl[1] wl[0]
*.PININFO bl:B bl_b:B sramvcc:I sramvss:I wl[1]:I wl[0]:I
Xibit[0] bl bl_b sramvcc sramvss wl[0] x78hcc5bit
Xibit[1] bl bl_b sramvcc sramvss wl[1] x78hcc5bit
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5edg1x2
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5edg1x2 bl[1] bl[0] sramvcc[1] sramvcc[0] sramvss
*.PININFO bl[1]:B bl[0]:B sramvcc[1]:I sramvcc[0]:I sramvss:I
Xibitedge[1] bl[1] sramvcc[1] sramvss x78hcc5edg
Xibitedge[0] bl[0] sramvcc[0] sramvss x78hcc5edg
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5drvtrk2x2
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5drvtrk2x2 bl_bnoconn[0] dbl noconn[0] noconn[1] dwl sramvcc sramvcc_noconn
+ sramvss wl[1] wl[0]
*.PININFO bl_bnoconn[0]:B dbl:B noconn[0]:B noconn[1]:B dwl:I sramvcc:I sramvcc_noconn:I sramvss:I wl[1]:I wl[0]:I
Xigap[0] noconn[0] bl_bnoconn[0] wl[0] sramvcc_noconn sramvss sramvss x78hcc5drvtrk
Xigap[1] noconn[0] bl_bnoconn[0] wl[1] sramvcc_noconn sramvss sramvss x78hcc5drvtrk
Xibit[0] noconn[1] dbl dwl sramvcc sramvss sramvss x78hcc5drvtrk
Xibit[1] noconn[1] dbl dwl sramvcc sramvss sramvss x78hcc5drvtrk
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5ncntrk2x2
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5ncntrk2x2 bl_bnoconn[0] dbl noconn[0] noconn[1] sramvcc sramvcc_noconn
+ sramvss wl[1] wl[0]
*.PININFO bl_bnoconn[0]:B dbl:B noconn[0]:B noconn[1]:B sramvcc:I sramvcc_noconn:I sramvss:I wl[1]:I wl[0]:I
Xigap[0] noconn[0] bl_bnoconn[0] dbl_noconn[0] wl[0] sramvcc_noconn sramvss sramvss x78hcc5ncntrk
Xigap[1] noconn[0] bl_bnoconn[0] dbl_noconn[0] wl[1] sramvcc_noconn sramvss sramvss x78hcc5ncntrk
Xibit[0] noconn[1] dbl dbl_noconn[1] sramvss sramvcc sramvss sramvss x78hcc5ncntrk
Xibit[1] noconn[1] dbl dbl_noconn[1] sramvss sramvcc sramvss sramvss x78hcc5ncntrk
.ENDS

************************************************************************
* Library Name: intel78sram
* Cell Name:    x78hcc5ldtrk2x2
* View Name:    schematic
************************************************************************
.SUBCKT x78hcc5ldtrk2x2 bl_bnoconn[0] dbl noconn[0] noconn[1] sramvcc sramvcc_noconn
+ sramvss wl[1] wl[0]
*.PININFO bl_bnoconn[0]:B dbl:B noconn[0]:B noconn[1]:B sramvcc:I sramvcc_noconn:I sramvss:I wl[1]:I wl[0]:I
Xigap[0] noconn[0] bl_bnoconn[0] wl[0] sramvcc_noconn sramvss sramvss x78hcc5ldtrk
Xigap[1] noconn[0] bl_bnoconn[0] wl[1] sramvcc_noconn sramvss sramvss x78hcc5ldtrk
Xibit[0] noconn[1] dbl sramvss sramvcc sramvss sramvss x78hcc5ldtrk
Xibit[1] noconn[1] dbl sramvss sramvcc sramvss sramvss x78hcc5ldtrk
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_centimer activered#[1] activered#[0] activered1l[1]
+ activered1l[0] bankgrant1h blpch clkbank clkrd clkrd2h2l clksaemx clkwl clkwr2h2l
+ clkwrsynckicknn clkwrysel# finekick[3] finekick[2] finekick[1] finekick[0] fz_asynckick#
+ fz_asyncrd# fz_asyncwr# fz_finekick#[3] fz_finekick#[2] fz_finekick#[1] fz_finekick#[0]
+ fz_rassel#[2] fz_rassel#[1] fz_rassel#[0] fz_rdwlcut# fz_rdwlpw#[3] fz_rdwlpw#[2]
+ fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw#[1] fz_saepw#[0] fz_synckick fz_syncrd fz_syncwr
+ fz_trbwassel#[2] fz_trbwassel#[1] fz_trbwassel#[0] fz_trkwllvl#[2] fz_trkwllvl#[1]
+ fz_trkwllvl#[0] fz_wassel#[2] fz_wassel#[1] fz_wassel#[0] fz_wrwlcut# fz_wrwlpw#[1]
+ fz_wrwlpw#[0] grant1l grant2h hi#[7] hi#[6] hi#[5] hi#[4] hi#[3] hi#[2] hi#[1]
+ hi#[0] ia_hi#[2] ia_hi#[1] ia_hi#[0] ia_mid#[2] ia_mid#[1] ia_mid#[0] ia_wle#[1]
+ ia_wle#[0] iwren1h iwren1l2l iwren2h3h lyaennn lyanowl# lyasel mid#[7] mid#[6]
+ mid#[5] mid#[4] mid#[3] mid#[2] mid#[1] mid#[0] nbl_kicknn_dn nbl_kicknn_up nblkick
+ pickside1l[1] pickside1l[0] rdwlclkmx rdwlpw[3] rdwlpw[2] rdwlpw[1] rdwlpw[0]
+ redactive1l# saenn_dn saenn_up sapchnn_dn sapchnn_up sideen[0] slpen1l# trkwllvlnn[2]
+ trkwllvlnn[1] trkwllvlnn[0] turbomode# vcc vss waenn_dn[2] waenn_dn[1] waenn_dn[0]
+ waenn_up[2] waenn_up[1] waenn_up[0] wayselbnk[3] wayselbnk[2] wayselbnk[1] wayselbnk[0]
+ wleaddrdec[3] wleaddrdec[2] wleaddrdec[1] wleaddrdec[0] wllvlnn[2] wllvlnn[1]
+ wllvlnn[0] wrclk_dn wrclk_up wrdataen_dn wrdataen_up wrwlclkmx wrwlpw[1] wrwlpw[0]
+ yseladdrdec[3] yseladdrdec[2] yseladdrdec[1] yseladdrdec[0]
*.PININFO activered#[1]:I activered#[0]:I activered1l[1]:O activered1l[0]:O bankgrant1h:I blpch:O clkbank:I clkrd:O clkrd2h2l:O clksaemx:O clkwl:O clkwr2h2l:O clkwrsynckicknn:O clkwrysel#:O finekick[3]:O finekick[2]:O finekick[1]:O finekick[0]:O fz_asynckick#:I fz_asyncrd#:I
*.PININFO fz_asyncwr#:I fz_finekick#[3]:I fz_finekick#[2]:I fz_finekick#[1]:I fz_finekick#[0]:I fz_rassel#[2]:I fz_rassel#[1]:I fz_rassel#[0]:I fz_rdwlcut#:I fz_rdwlpw#[3]:I fz_rdwlpw#[2]:I fz_rdwlpw#[1]:I fz_rdwlpw#[0]:I fz_saepw#[1]:I fz_saepw#[0]:I fz_synckick:O fz_syncrd:O fz_syncwr:O fz_trbwassel#[2]:I fz_trbwassel#[1]:I
*.PININFO fz_trbwassel#[0]:I fz_trkwllvl#[2]:I fz_trkwllvl#[1]:I fz_trkwllvl#[0]:I fz_wassel#[2]:I fz_wassel#[1]:I fz_wassel#[0]:I fz_wrwlcut#:I fz_wrwlpw#[1]:I fz_wrwlpw#[0]:I grant1l:I grant2h:I hi#[7]:O hi#[6]:O hi#[5]:O hi#[4]:O hi#[3]:O hi#[2]:O hi#[1]:O hi#[0]:O
*.PININFO ia_hi#[2]:I ia_hi#[1]:I ia_hi#[0]:I ia_mid#[2]:I ia_mid#[1]:I ia_mid#[0]:I ia_wle#[1]:I ia_wle#[0]:I iwren1h:I iwren1l2l:I iwren2h3h:I lyaennn:O lyanowl#:I lyasel:I mid#[7]:O mid#[6]:O mid#[5]:O mid#[4]:O mid#[3]:O mid#[2]:O
*.PININFO mid#[1]:O mid#[0]:O nbl_kicknn_dn:O nbl_kicknn_up:O nblkick:I pickside1l[1]:O pickside1l[0]:O rdwlclkmx:I rdwlpw[3]:O rdwlpw[2]:O rdwlpw[1]:O rdwlpw[0]:O redactive1l#:O saenn_dn:O saenn_up:O sapchnn_dn:O sapchnn_up:O sideen[0]:I slpen1l#:O trkwllvlnn[2]:O
*.PININFO trkwllvlnn[1]:O trkwllvlnn[0]:O turbomode#:I vcc:I vss:I waenn_dn[2]:O waenn_dn[1]:O waenn_dn[0]:O waenn_up[2]:O waenn_up[1]:O waenn_up[0]:O wayselbnk[3]:I wayselbnk[2]:I wayselbnk[1]:I wayselbnk[0]:I wleaddrdec[3]:O wleaddrdec[2]:O wleaddrdec[1]:O wleaddrdec[0]:O wllvlnn[2]:O
*.PININFO wllvlnn[1]:O wllvlnn[0]:O wrclk_dn:O wrclk_up:O wrdataen_dn:O wrdataen_up:O wrwlclkmx:I wrwlpw[1]:O wrwlpw[0]:O yseladdrdec[3]:O yseladdrdec[2]:O yseladdrdec[1]:O yseladdrdec[0]:O
Xirep6[0] mid_pdec_in_latched[0] mid_pdec_in_latched_rep0[0] vcc vss i0mbfn000ab1n02x5
Xirep6[1] hi_pdec_in_latched[1] hi_pdec_in_latched_rep[1] vcc vss i0mbfn000ab1n06x5
Xirdchp_async rdclk_del asyncrd rdclk_chp_async vcc vss i0mnand02ab1n02x5
Xrdclk_chp_bfm1 rdclk_chp_async_b rdclk_chp_async_bfm vcc vss i0mbfm201ab1n03x5
Xirdclksel_chp rdclk_del rdclk_chp_async_bfm rdclk_chp vcc vss i0mnor002ab1n03x5
Xrdclk_chp_inv1 rdclk_chp_async rdclk_chp_async_b vcc vss i0minv000ab1n02x5
Xirep5 trbmode2h2l_rep trbmode2h2l_rep_rep vcc vss i0mbfn000ac1n02x5
Xirep3[2] mid_pdec_in_latched[2] mid_pdec_in_latched_rep[2] vcc vss i0mbfm201ac1n06x5
Xirep4 trbmode2h2l trbmode2h2l_rep vcc vss i0mbfm201ac1n03x5
Xirep3[1] mid_pdec_in_latched[1] mid_pdec_in_latched_rep[1] vcc vss i0mbfm201ac1n06x5
Xirep3[0] mid_pdec_in_latched_rep0[0] mid_pdec_in_latched_rep[0] vcc vss i0mbfm201ab1n06x5
Xirep2 wrwlclkmx_del1 wrwlclkmx_del1_rep vcc vss i0mbfm201ac1n02x5
Xirep1 wren1l2h_del1#_rep wren1l2h_del1# vcc vss i0mbfm402ac1n02x5
Xipchdel2 pch_del pch_del2 vcc vss i0mbfm202ab1n03x5
Xgnac0 fz_finekick#[1] vcc vss i0mydp122ub1n00x5
Xipchchpdrv_del clkwl2h2l_del1 pch_del vcc vss i0mbfm604ab1n03x5
Xipchgendrv clkwl pch_del2 blpch vcc vss i0mnor002ab1n12x5
Xiclkbank2h2l_chp# clkwl clkwl2h2l_del1 clkbank2h2l_chp# vcc vss i0mnor002ab1n03x5
Xiclkbank2h2l# clkwl clkbank2h2l# vcc vss i0minv000ab1n06x5
Xiclkbank2h# clkbank grant1l clkbank2h# vcc vss i0mnand02ab1n10x5
Xiclkbank2h2l_chp clkbank2h# clkbank2h2l_chp# clkbank2h2l_chp vcc vss i0mnand02ab1n06x5
Xiclkbank2h2l clkbank2h# clkbank2h2l# clkbank2h2l vcc vss i0mnand02ab1n06x5
Xiclkwl2h2l_del0 clkwl clkwl2h2l_del0 vcc vss i0mbfm201ab1n02x5
Xiclkbank2h2l_chp0# clkwl clkwl2h2l_del0 clkbank2h2l_chp0# vcc vss i0mnor002ab1n03x5
Xiclkbank2h2l_chp0 clkbank2h# clkbank2h2l_chp0# clkbank2h2l_chp0 vcc vss i0mnand02ab1n10x5
Xclkdrv clkbank clkbank# vcc vss i0mcinv00ab1n04x5
Xiwren1l2ldrv iwren1l2l iwren1l2l# vcc vss i0minv000ac1n02x5
Xiwrwlcut grant2h fz_wrwlcut# grant2hwr# vcc vss i0mnand02ac1n02x5
Xirdwlcut grant2h fz_rdwlcut# grant2hrd vcc vss i0mand002ac1n02x5
Xiasyncrd fz_asyncrd# asyncrd vcc vss i0minv000ac1n02x5
Xisync asyncrd fz_syncrd vcc vss i0minv000ac1n03x5
Xisaepw[1] fz_saepw#[1] saepw[1] vcc vss i0minv000ac1n02x5
Xisaepw[0] fz_saepw#[0] saepw[0] vcc vss i0minv000ac1n02x5
Xitrkwllvlnn[2] fz_trkwllvl#[2] trkwllvlnn[2] vcc vss i0mbfn000ac1n09x5
Xitrkwllvlnn[1] fz_trkwllvl#[1] trkwllvlnn[1] vcc vss i0mbfn000ac1n09x5
Xitrkwllvlnn[0] fz_trkwllvl#[0] trkwllvlnn[0] vcc vss i0mbfn000ac1n09x5
Xifaststdtrk[3] fz_rdwlpw#[3] rdwlpw[3] vcc vss i0minv000ac1n03x5
Xifaststdtrk[2] fz_rdwlpw#[2] rdwlpw[2] vcc vss i0minv000ac1n03x5
Xifaststdtrk[1] fz_rdwlpw#[1] rdwlpw[1] vcc vss i0minv000ac1n03x5
Xifaststdtrk[0] fz_rdwlpw#[0] rdwlpw[0] vcc vss i0minv000ac1n03x5
Xisaegen asyncrd clkbank clksaemx rden2h# rden2l rdwlcut saepw[1] saepw[0] fz_syncrd
+ vcc vss rdclk_del issastsaegen
Xitrbmode2h2l clkbank2h2l_chp turbomode# trbmode2h2l vcc vss i0mlun090ac1d06x5
Xitrbmode2h2l# trbmode2h2l trbmode2h2l# vcc vss i0minv000ac1n03x5
Xirassel[2] trbmode2h2l fz_rassel#[2] wllvlnn[2] vcc vss i0morn002ac1n09x5
Xirassel[1] trbmode2h2l_rep_rep fz_rassel#[1] wllvlnn[1] vcc vss i0morn002ac1n09x5
Xirassel[0] trbmode2h2l fz_rassel#[0] wllvlnn[0] vcc vss i0morn002ac1n09x5
Xiwasselmux[2] fz_wassel#[2] trbmode2h2l# trbmode2h2l fz_trbwassel#[2] wassel[2]
+ vcc vss i0maoi022ac1n06x5
Xiwasselmux[1] fz_wassel#[1] trbmode2h2l# trbmode2h2l fz_trbwassel#[1] wassel[1]
+ vcc vss i0maoi022ac1n06x5
Xiwasselmux[0] fz_wassel#[0] trbmode2h2l# trbmode2h2l fz_trbwassel#[0] wassel[0]
+ vcc vss i0maoi022ac1n06x5
Xinbl_kick_up nblkick# nbl_kicknn_up vcc vss i0mbfn000ab1n36x5
Xinbl_kick_dn nblkick# nbl_kicknn_dn vcc vss i0mbfn000ab1n36x5
Xiwaenn_up[2] wassel[2] waenn_up[2] vcc vss i0minv000ac1n15x5
Xiwaenn_up[1] wassel[1] waenn_up[1] vcc vss i0minv000ac1n15x5
Xiwaenn_up[0] wassel[0] waenn_up[0] vcc vss i0minv000ac1n15x5
Xiwaenn_dn[2] wassel[2] waenn_dn[2] vcc vss i0minv000ac1n15x5
Xiwaenn_dn[1] wassel[1] waenn_dn[1] vcc vss i0minv000ac1n15x5
Xiwaenn_dn[0] wassel[0] waenn_dn[0] vcc vss i0minv000ac1n15x5
Xiwren1l2h_del0 wren1l2h# wren1l2h_del0# vcc vss i0mbfm807ac1n03x5
Xiwren1l2h_del1 wren1l2h_del0# wren1l2h_del1#_rep vcc vss i0mbfm402ac1n03x5
Xinblen_latch nblkick wren1l2h# wren1l2h_cg# vcc vss i0mlsn080ac1n03x5
Xiwassel wassel[0] wassel[1] wassel[2] wassel# vcc vss i0mnor003ac1n03x5
Xinblen wren1l2h_cg# wassel# nblen vcc vss i0mnor002ac1n03x5
Xinblen_del nblen nblen_del vcc vss i0mbfm201ac1n03x5
Xinblkickmx nblkick nblen_del nblkick# vcc vss i0mnand02ab1n06x5
Xiwrwlpw[1] fz_wrwlpw#[1] wrwlpw[1] vcc vss i0minv000ac1n09x5
Xiwrwlpw[0] fz_wrwlpw#[0] wrwlpw[0] vcc vss i0minv000ac1n09x5
Xifinekick[3] fz_finekick#[3] finekick[3] vcc vss i0minv000ac1n02x5
Xifinekick[2] fz_finekick#[2] finekick[2] vcc vss i0minv000ac1n02x5
Xifinekick[1] fz_finekick#[1] finekick[1] vcc vss i0minv000ac1n02x5
Xifinekick[0] fz_finekick#[0] finekick[0] vcc vss i0minv000ac1n02x5
Xisyncwr fz_asyncwr# fz_syncwr vcc vss i0mbfn000ac1n02x5
Xisynckick fz_asynckick# fz_asyncwr# fz_synckick vcc vss i0mand002ac1n03x5
Xclkrd2hdrv clkbank grant1l iwren1l2l# clkrd2h# vcc vss i0mnand03ab1n06x5
Xclkrd2ldrv clkbank# grant2hrd iwren2h3h# clkrd2l# vcc vss i0mnand03ab1n03x5
Xclkrd2hor2ldrv clkrd2h# clkrd2l# clkrd2h_del# clkrd2h2l vcc vss i0mnand03ab1n06x5
Xiclkrd2h_del clkrd2h# clkrd2h_del# vcc vss i0mbfm807ab1n03x5
Xclkwr2hdrv clkbank grant1l iwren1l2l clkwr2h# vcc vss i0mnand03ab1n06x5
Xiwren2h3hdrv iwren2h3h iwren2h3h# vcc vss i0minv000ac1n06x5
Xiclkwr2h_del clkwr2h# clkwr2h_del# vcc vss i0mbfm807ab1n03x5
Xwren2lgen iwren2h3h# grant2hwr# grant2hwr vcc vss i0mnor002ab1n03x5
Xclkwr2ldrv clkbank# grant2hwr clkwr2lnn vcc vss i0mnand02ab1n06x5
Xiclkwr2l_del clkwr2lnn clkwr2lnn_del vcc vss i0mbfm807ab1n03x5
Xiwren2l clkbank grant2hwr grant2lwr vcc vss i0mlsn080ac1n03x5
Xclkwr3hdrv clkbank grant2lwr clkwr3hnn vcc vss i0mnand02ab1n03x5
Xclkwr2hor2ldrv clkwr2h# clkwr2lnn clkwr2h_del# clkwr2h2l vcc vss i0mnand03ab1n06x5
Xiclkwr2l3h clkwr2lnn clkwr2lnn_del clkwr3hnn clkwr2l3h vcc vss i0mnand03ab1n06x5
Xiwrclk2h2lkick wrwlclkmx_del0 wrclk2h2lkick vcc vss i0mbfn000ab1n03x5
Xclkwr2l3hdrv clkwr2l3h wrclk2h2lkick clkwrsynckicknn vcc vss i0mnand02ab1n06x5
Xiwrclkdrv_del0 wrwlclkmx wrwlclkmx_del0 vcc vss i0mbfm201ab1n06x5
Xiwrclkdrv wrwlclkmx_del0 wrwlclkmx_del3 wrwlclkmx# vcc vss i0mnor002ab1n12x5
Xiwrclkdrv_up wrwlclkmx# wrclk_up vcc vss i0minv000ab1d42x5
Xiwrclkdrv_dn wrwlclkmx# wrclk_dn vcc vss i0minv000ab1d42x5
Xirdclk_del rdwlclkmx rdclk_del vcc vss i0mbfn000ab1n06x5
Xrdorwrclkdrv rdwlclkmx rdclk_del wrwlclkmx clkwl2h2l# vcc vss i0mnor003ab1n10x5
Xclkwrcoldrv wrwlclkmx_del0 wrwlclkmx_del1 clkwrysel# vcc vss i0mnor002ab1n10x5
Xiclkrdysel rdclk_chp clkrd vcc vss i0minv000ab1n09x5
Xclkrdyseldrv_del rdclk_del rdwlclkmx_del vcc vss i0mbfm807ac1n03x5
Xclkrdyseldrv rdwlclkmx_del_rep rdclk_del clkpchrdysel# vcc vss i0mnor002ab1n03x5
Xiwlclockgen clkwl2h2l# clkwl vcc vss i0minv000ab1n12x5
Xirden2l clkbank rden2h# rden2l# vcc vss i0mlsn080ac1n03x5
Xirden2l# rden2l_rep# rden2l vcc vss i0minv000ac1n02x5
Xicutrdwlen fz_rdwlcut# rdwlcut vcc vss i0minv000ac1n02x5
Xirden2h grant2h iwren2h3h# rden2h# vcc vss i0mnand02ac1n02x5
Xsaenndrvup clksaemx saenn_up vcc vss i0minv000ab1n36x5
Xsaenndrvdn clksaemx saenn_dn vcc vss i0minv000ab1n36x5
Xsapchnndrv clksaemx clkpchrdysel sapch vcc vss i0mnor002ab1n12x5
Xsapchdrvup sapch sapchnn_up vcc vss i0minv000ab1n36x5
Xsapchdrvdn sapch sapchnn_dn vcc vss i0minv000ab1n36x5
Xwrdataendrvup wrenlya1l2h# wrdataen_up vcc vss i0minv000ac1n36x5
Xwrdataendrvdn wrenlya1l2h# wrdataen_dn vcc vss i0minv000ac1n36x5
Xlyaseldrv lyasel lyaennn vcc vss i0minv000ac1n24x5
Xwrdataenblyadrv wrdataen lyaennn wrenlya1l2h# vcc vss i0mnand02ac1n10x5
Xilyanowlsel lyaennn lyanowl# lyanowlsel vcc vss i0mnor002ac1n02x5
Xhi_pdec_dec[0] hi_pdec_in_latched_b[0] hi_pdec_in_latched_b[1] hi_pdec_in_latched_b[2]
+ hi_pdec_iout[7] vcc vss i0mnor003ab1n03x5
Xhi_pdec_dec[1] hi_pdec_in_latched[0] hi_pdec_in_latched_b[1] hi_pdec_in_latched_b[2]
+ hi_pdec_iout[6] vcc vss i0mnor003ab1n03x5
Xhi_pdec_dec[2] hi_pdec_in_latched_b[0] hi_pdec_in_latched_rep[1] hi_pdec_in_latched_b[2]
+ hi_pdec_iout[5] vcc vss i0mnor003ab1n03x5
Xhi_pdec_dec[3] hi_pdec_in_latched[0] hi_pdec_in_latched_rep[1] hi_pdec_in_latched_b[2]
+ hi_pdec_iout[4] vcc vss i0mnor003ab1n03x5
Xhi_pdec_dec[4] hi_pdec_in_latched_b[0] hi_pdec_in_latched_b[1] hi_pdec_in_latched[2]
+ hi_pdec_iout[3] vcc vss i0mnor003ab1n03x5
Xhi_pdec_dec[5] hi_pdec_in_latched[0] hi_pdec_in_latched_b[1] hi_pdec_in_latched[2]
+ hi_pdec_iout[2] vcc vss i0mnor003ab1n03x5
Xhi_pdec_dec[6] hi_pdec_in_latched_b[0] hi_pdec_in_latched_rep[1] hi_pdec_in_latched[2]
+ hi_pdec_iout[1] vcc vss i0mnor003ab1n03x5
Xhi_pdec_dec[7] hi_pdec_in_latched[0] hi_pdec_in_latched_rep[1] hi_pdec_in_latched[2]
+ hi_pdec_iout[0] vcc vss i0mnor003ab1n03x5
Xhi_pdec_decdrv[0] hi_pdec_iout[7] hi#[7] vcc vss i0minv000ac1n09x5
Xhi_pdec_decdrv[1] hi_pdec_iout[6] hi#[6] vcc vss i0minv000ac1n09x5
Xhi_pdec_decdrv[2] hi_pdec_iout[5] hi#[5] vcc vss i0minv000ac1n09x5
Xhi_pdec_decdrv[3] hi_pdec_iout[4] hi#[4] vcc vss i0minv000ac1n09x5
Xhi_pdec_decdrv[4] hi_pdec_iout[3] hi#[3] vcc vss i0minv000ac1n09x5
Xhi_pdec_decdrv[5] hi_pdec_iout[2] hi#[2] vcc vss i0minv000ac1n09x5
Xhi_pdec_decdrv[6] hi_pdec_iout[1] hi#[1] vcc vss i0minv000ac1n09x5
Xhi_pdec_decdrv[7] hi_pdec_iout[0] hi#[0] vcc vss i0minv000ac1n09x5
Xhi_pdec_ininv[0] hi_pdec_in_latched[0] hi_pdec_in_latched_b[0] vcc vss i0minv000ac1n03x5
Xhi_pdec_ininv[1] hi_pdec_in_latched_rep[1] hi_pdec_in_latched_b[1] vcc vss i0minv000ac1n03x5
Xhi_pdec_ininv[2] hi_pdec_in_latched[2] hi_pdec_in_latched_b[2] vcc vss i0minv000ac1n03x5
Xhi_pdec_inlatch[0] clkbank2h2l_chp0 ia_hi#[0] hi_pdec_in_latched[0] vcc vss i0mlun090ac1d06x5
Xhi_pdec_inlatch[1] clkbank2h2l_chp0 ia_hi#[1] hi_pdec_in_latched[1] vcc vss i0mlun090ac1d06x5
Xhi_pdec_inlatch[2] clkbank2h2l_chp0 ia_hi#[2] hi_pdec_in_latched[2] vcc vss i0mlun090ac1d06x5
Xmid_pdec_dec[0] mid_pdec_in_latched_b[0] mid_pdec_in_latched_b[1] mid_pdec_in_latched_b[2]
+ mid_pdec_iout[7] vcc vss i0mnor003ab1n03x5
Xmid_pdec_dec[1] mid_pdec_in_latched_rep[0] mid_pdec_in_latched_b[1] mid_pdec_in_latched_b[2]
+ mid_pdec_iout[6] vcc vss i0mnor003ab1n03x5
Xmid_pdec_dec[2] mid_pdec_in_latched_b[0] mid_pdec_in_latched_rep[1] mid_pdec_in_latched_b[2]
+ mid_pdec_iout[5] vcc vss i0mnor003ab1n03x5
Xmid_pdec_dec[3] mid_pdec_in_latched_rep[0] mid_pdec_in_latched_rep[1] mid_pdec_in_latched_b[2]
+ mid_pdec_iout[4] vcc vss i0mnor003ab1n03x5
Xmid_pdec_dec[4] mid_pdec_in_latched_b[0] mid_pdec_in_latched_b[1] mid_pdec_in_latched_rep_rep[2]
+ mid_pdec_iout[3] vcc vss i0mnor003ab1n03x5
Xmid_pdec_dec[5] mid_pdec_in_latched_rep[0] mid_pdec_in_latched_b[1] mid_pdec_in_latched_rep_rep[2]
+ mid_pdec_iout[2] vcc vss i0mnor003ab1n03x5
Xmid_pdec_dec[6] mid_pdec_in_latched_b[0] mid_pdec_in_latched_rep[1] mid_pdec_in_latched_rep_rep[2]
+ mid_pdec_iout[1] vcc vss i0mnor003ab1n03x5
Xmid_pdec_dec[7] mid_pdec_in_latched_rep[0] mid_pdec_in_latched_rep[1] mid_pdec_in_latched_rep_rep[2]
+ mid_pdec_iout[0] vcc vss i0mnor003ab1n03x5
Xmid_pdec_decdrv[0] mid_pdec_iout[7] mid#[7] vcc vss i0minv000ac1n09x5
Xmid_pdec_decdrv[1] mid_pdec_iout[6] mid#[6] vcc vss i0minv000ac1n09x5
Xmid_pdec_decdrv[2] mid_pdec_iout[5] mid#[5] vcc vss i0minv000ac1n09x5
Xmid_pdec_decdrv[3] mid_pdec_iout[4] mid#[4] vcc vss i0minv000ac1n09x5
Xmid_pdec_decdrv[4] mid_pdec_iout[3] mid#[3] vcc vss i0minv000ac1n09x5
Xmid_pdec_decdrv[5] mid_pdec_iout[2] mid#[2] vcc vss i0minv000ac1n09x5
Xmid_pdec_decdrv[6] mid_pdec_iout[1] mid#[1] vcc vss i0minv000ac1n09x5
Xmid_pdec_decdrv[7] mid_pdec_iout[0] mid#[0] vcc vss i0minv000ac1n09x5
Xmid_pdec_ininv[0] mid_pdec_in_latched_rep[0] mid_pdec_in_latched_b[0] vcc vss i0minv000ac1n03x5
Xmid_pdec_ininv[1] mid_pdec_in_latched_rep[1] mid_pdec_in_latched_b[1] vcc vss i0minv000ac1n03x5
Xmid_pdec_ininv[2] mid_pdec_in_latched_rep_rep[2] mid_pdec_in_latched_b[2] vcc vss i0minv000ac1n03x5
Xmid_pdec_inlatch[0] clkbank2h2l_chp0 ia_mid#[0] mid_pdec_in_latched[0] vcc vss i0mlun090ac1d06x5
Xmid_pdec_inlatch[1] clkbank2h2l_chp0 ia_mid#[1] mid_pdec_in_latched[1] vcc vss i0mlun090ac1d06x5
Xmid_pdec_inlatch[2] clkbank2h2l_chp0 ia_mid#[2] mid_pdec_in_latched[2] vcc vss i0mlun090ac1d06x5
Xwle_pdec_dec[0] wle_pdec_in_latched_b[0] wle_pdec_in_latched_b[1] wle_pdec_iout[0]
+ vcc vss i0mnand02ac1n03x5
Xwle_pdec_dec[1] wle_pdec_in_latched[0] wle_pdec_in_latched_b[1] wle_pdec_iout[1]
+ vcc vss i0mnand02ac1n03x5
Xwle_pdec_dec[2] wle_pdec_in_latched_b[0] wle_pdec_in_latched[1] wle_pdec_iout[2]
+ vcc vss i0mnand02ac1n03x5
Xwle_pdec_dec[3] wle_pdec_in_latched[0] wle_pdec_in_latched[1] wle_pdec_iout[3]
+ vcc vss i0mnand02ac1n03x5
Xwle_pdec_decdrv[0] wle_pdec_iout[0] wleaddrdec[0] vcc vss i0minv000ac1n09x5
Xwle_pdec_decdrv[1] wle_pdec_iout[1] wleaddrdec[1] vcc vss i0minv000ac1n09x5
Xwle_pdec_decdrv[2] wle_pdec_iout[2] wleaddrdec[2] vcc vss i0minv000ac1n09x5
Xwle_pdec_decdrv[3] wle_pdec_iout[3] wleaddrdec[3] vcc vss i0minv000ac1n09x5
Xwle_pdec_ininv[0] wle_pdec_in_latched[0] wle_pdec_in_latched_b[0] vcc vss i0minv000ac1n03x5
Xwle_pdec_ininv[1] wle_pdec_in_latched[1] wle_pdec_in_latched_b[1] vcc vss i0minv000ac1n03x5
Xwle_pdec_inlatch[0] clkbank2h2l ia_wle#[0] wle_pdec_in_latched[0] vcc vss i0mlun090ac1d06x5
Xwle_pdec_inlatch[1] clkbank2h2l ia_wle#[1] wle_pdec_in_latched[1] vcc vss i0mlun090ac1d06x5
Xwaysellatch[3] clkbank2h2l_chp wayselbnk[3] yseladdrdec[3] vcc vss i0mlsn080ac1n02x5
Xwaysellatch[2] clkbank2h2l_chp wayselbnk[2] yseladdrdec[2] vcc vss i0mlsn080ac1n02x5
Xwaysellatch[1] clkbank2h2l_chp wayselbnk[1] yseladdrdec[1] vcc vss i0mlsn080ac1n02x5
Xwaysellatch[0] clkbank2h2l_chp wayselbnk[0] yseladdrdec[0] vcc vss i0mlsn080ac1n02x5
Xsidelatch clkbank2h2l_chp0 sideen[0] sideen1l#[0] vcc vss i0mlun090ac1n03x5
Xipickside[0] sideen1l#[0] pickside1l[0] vcc vss i0minv000ab1n06x5
Xipickside[1] sideen1l#[0] pickside1l[1] vcc vss i0mbfn000ab1n06x5
Xredwldrv[1] redaddr1l[1] activered1l[1] vcc vss i0mbfn000ab1n02x5
Xredwldrv[0] redaddr1l[0] activered1l[0] vcc vss i0mbfn000ab1n02x5
Xredactgeb redaddr1l[0] redaddr1l[1] lyanowlsel redactive1l# vcc vss i0mnor003ac1n06x5
Xredrowlatch[1] clkbank2h2l activered#[1] redaddr1l[1] vcc vss i0mlun090ac1n03x5
Xredrowlatch[0] clkbank2h2l activered#[0] redaddr1l[0] vcc vss i0mlun090ac1n03x5
Xslpretain_latch clkbank2h2l_chp0 bankgrant1h slpen1l# vcc vss i0mlsn080ac1n03x5
Xwren1hnand bankgrant1h iwren1h wren1h# vcc vss i0mnand02ac1n03x5
Xwren_latch clkbank2h2l_chp0 wren1h# wren1l2h# vcc vss i0mlsn080ac1n03x5
Xiwrdataen wren1l2h# wren1l2h_del1# wrdataen vcc vss i0mnand02ac1n03x5
Xiclkwl2h2l_del1 clkwl clkwl2h2l_del1 vcc vss i0mbfm604ab1n03x5
Xiclkpchrdysel clkpchrdysel# clkpchrdysel vcc vss i0minv000ab1n03x5
Xiwrclkdrv_del1 wrwlclkmx_del0 wrwlclkmx_del1 vcc vss i0mbfm402ab1n03x5
Xiwrclkdrv_del2 wrwlclkmx_del1_rep wrwlclkmx_del3 vcc vss i0mbfm807ac1n03x5
Xirep rdwlclkmx_del rdwlclkmx_del_rep vcc vss i0mbfm201ab1n03x5
Xirep0 rden2l# rden2l_rep# vcc vss i0mbfn000ac1n03x5
Xirep6[2] mid_pdec_in_latched_rep[2] mid_pdec_in_latched_rep_rep[2] vcc vss i0mbfn000ac1n06x5
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahcctrkio
* View Name:    schematic
************************************************************************
.SUBCKT issahcctrkio clkwr2lnn fine_kick[3] fine_kick[2] fine_kick[1] fine_kick[0]
+ nblkick rdwl rdwlclkmx rdwlpw[3] rdwlpw[2] rdwlpw[1] rdwlpw[0] synckick syncrd
+ syncwr trkbl trkblin trkwl trkwllvlnn[2] trkwllvlnn[1] trkwllvlnn[0] vcc vssx
+ wrwl wrwlclkmx wrwlpw[1] wrwlpw[0]
*.PININFO clkwr2lnn:I fine_kick[3]:I fine_kick[2]:I fine_kick[1]:I fine_kick[0]:I nblkick:O rdwl:I rdwlclkmx:O rdwlpw[3]:I rdwlpw[2]:I rdwlpw[1]:I rdwlpw[0]:I synckick:I syncrd:I syncwr:I trkbl:B trkblin:O trkwl:O trkwllvlnn[2]:I trkwllvlnn[1]:I
*.PININFO trkwllvlnn[0]:I vcc:I vssx:I wrwl:I wrwlclkmx:O wrwlpw[1]:I wrwlpw[0]:I
Xi1_io wrwlnn wrwlnn n0 vcc vssx no2_pcell_issahcctrk256slc_4654196017136894227
Xiwrcolsel n0 wrcolsel wrcolselnn vcc vssx no2_pcell_issahcctrk256slc_8401311939530474654
Xitrig trkbl trkbl trig vcc vssx no2_pcell_issahcctrk256slc_12795608570872162145
Xifinedel vcc kick kick_del fine_kick[3] fine_kick[2] fine_kick[1] fine_kick[0]
+ vcc vssx issafinedl
Xifinedl vcc rdwlnn rdwlnn_del rdwlpw[3] rdwlpw[2] rdwlpw[1] rdwlpw[0] vcc vssx issafinedl
Miwldrvp trkwl trkwl_innn vcc vcc phpasvt W=3.0 L=14n M=5 LVSEXACTMATCH=0
Mipwlud01 npwlud trkwllvlnn[0] trkwl vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mipwlud1 vssx trkwllvlnn[1] trkwl vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mipwlud2 vssx trkwllvlnn[2] trkwl vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
Miblpchnn trkbl pcnn vcc vcc phpasvt W=3.0 L=14n M=2 LVSEXACTMATCH=0
MM1 trkblin pcnn vcc vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Mipwlud00 vssx trkwllvlnn[0] npwlud vcc phpasvt W=3.0 L=14n M=1 LVSEXACTMATCH=0
Xicomp_del nblkicknn_del wrwlpw[1] wrwlpw[0] trig_del vcc vssx issawrstdtrkdl
Xiwrwledrv wrwlnn wrwlclkmx vcc vssx inv_pcell_issahcctrk256slc_2751921099722748717
Xi0_io n1 wrcolsel vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
Xinblkick nblkicknn_del nblkick vcc vssx inv_pcell_issahcctrk256slc_4441547943835504324
Xisyncwr syncwr asyncwr vcc vssx inv_pcell_issahcctrk256slc_8007251406475222723
Xiclkwr2l clkwr2lnn clkwr2l vcc vssx inv_pcell_issahcctrk256slc_4441547943835504324
Xisynckick synckick asynckick vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
Xg2 rdwlnn trkwl_in vcc vssx inv_pcell_issahcctrk256slc_8007251406475222723
Xisync syncrd asyncrd vcc vssx inv_pcell_issahcctrk256slc_17870423651273743962
Xi2_io n0 n0 n1 vcc vssx na2_pcell_issahcctrk256slc_4654196017136894227
Xitrignblkick kick kick_del nblkicknn vcc vssx na2_pcell_issahcctrk256slc_7500890791422185133
Xtrkwlgate trkwl_in asyncrd trkwl_innn vcc vssx na2_pcell_issahcctrk256slc_15548040510760993482
Xinpch trkwl_innn wrcolselnn pcnn vcc vssx na2_pcell_issahcctrk256slc_4654196017136894227
Xirdwlclk rdwlnn rdwlnn_del rdwlclkmx vcc vssx na2_pcell_issahcctrk256slc_8401311939530474654
Miwrblb[0] trkblin wrcolsel nvss vssx nhpasvt W=3.0 L=14n M=6 LVSEXACTMATCH=0
Miwldrvn trkwl trkwl_innn vssx vssx nhpasvt W=3.0 L=14n M=3 LVSEXACTMATCH=0
Mmnvss nvss vcc vssx vssx nhpasvt W=3.0 L=14n M=8 LVSEXACTMATCH=0
Xikickdel nblkicknn nblkicknn_del vcc vssx issaudelbuf244pgensvt
Xitrkstdpg_0 trig kick asynckick synckick vcc vssx xf_pcell_issahcctrk256slc_1255097804650392361
Xisyncpg clkwr2l kick synckick asynckick vcc vssx xf_pcell_issahcctrk256slc_1255097804650392361
Xirdlwr asyncwr syncwr trig_del wrwlnn vcc vssx wrwl issastbypassrdl
Xirdlrd asyncrd syncrd trig rdwlnn vcc vssx rdwl issastbypassrdl
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issax2dec32
* View Name:    schematic
************************************************************************
.SUBCKT issax2dec32 c6saveb c6savet decvccb decvcct hi mid[7] mid[6] mid[5] mid[4]
+ mid[3] mid[2] mid[1] mid[0] slpen slpennn vcc vssx wlb[31] wlb[30] wlb[29] wlb[28]
+ wlb[27] wlb[26] wlb[25] wlb[24] wlb[23] wlb[22] wlb[21] wlb[20] wlb[19] wlb[18]
+ wlb[17] wlb[16] wlb[15] wlb[14] wlb[13] wlb[12] wlb[11] wlb[10] wlb[9] wlb[8]
+ wlb[7] wlb[6] wlb[5] wlb[4] wlb[3] wlb[2] wlb[1] wlb[0] wlenn[3] wlenn[2] wlenn[1]
+ wlenn[0] wllvl[2] wllvl[1] wllvl[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlt[31] wlt[30]
+ wlt[29] wlt[28] wlt[27] wlt[26] wlt[25] wlt[24] wlt[23] wlt[22] wlt[21] wlt[20]
+ wlt[19] wlt[18] wlt[17] wlt[16] wlt[15] wlt[14] wlt[13] wlt[12] wlt[11] wlt[10]
+ wlt[9] wlt[8] wlt[7] wlt[6] wlt[5] wlt[4] wlt[3] wlt[2] wlt[1] wlt[0]
*.PININFO c6saveb:I c6savet:I decvccb:B decvcct:B hi:I mid[7]:I mid[6]:I mid[5]:I mid[4]:I mid[3]:I mid[2]:I mid[1]:I mid[0]:I slpen:O slpennn:I vcc:I vssx:I wlb[31]:O wlb[30]:O wlb[29]:O
*.PININFO wlb[28]:O wlb[27]:O wlb[26]:O wlb[25]:O wlb[24]:O wlb[23]:O wlb[22]:O wlb[21]:O wlb[20]:O wlb[19]:O wlb[18]:O wlb[17]:O wlb[16]:O wlb[15]:O wlb[14]:O wlb[13]:O wlb[12]:O wlb[11]:O wlb[10]:O wlb[9]:O
*.PININFO wlb[8]:O wlb[7]:O wlb[6]:O wlb[5]:O wlb[4]:O wlb[3]:O wlb[2]:O wlb[1]:O wlb[0]:O wlenn[3]:I wlenn[2]:I wlenn[1]:I wlenn[0]:I wllvl[2]:I wllvl[1]:I wllvl[0]:I wllvlnn[2]:O wllvlnn[1]:O wllvlnn[0]:O wlt[31]:O
*.PININFO wlt[30]:O wlt[29]:O wlt[28]:O wlt[27]:O wlt[26]:O wlt[25]:O wlt[24]:O wlt[23]:O wlt[22]:O wlt[21]:O wlt[20]:O wlt[19]:O wlt[18]:O wlt[17]:O wlt[16]:O wlt[15]:O wlt[14]:O wlt[13]:O wlt[12]:O wlt[11]:O
*.PININFO wlt[10]:O wlt[9]:O wlt[8]:O wlt[7]:O wlt[6]:O wlt[5]:O wlt[4]:O wlt[3]:O wlt[2]:O wlt[1]:O wlt[0]:O
Xxdecrep slpen slpennn vcc vssx wlenn[3] wlenn[2] wlenn[1] wlenn[0] wle[3] wle[2]
+ wle[1] wle[0] wllvl[2] wllvl[1] wllvl[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] issaxdecrepeaters
Xxdec4[7] c6saveb c6savet decvccb decvcct shclkb[3] shclkb[2] shclkb[1] shclkb[0]
+ shclkt[3] shclkt[2] shclkt[1] shclkt[0] slpen slpen vcc vssx wlb[31] wlb[30] wlb[29]
+ wlb[28] wle[3] wle[2] wle[1] wle[0] wle[3] wle[2] wle[1] wle[0] wllvlnn[2] wllvlnn[1]
+ wllvlnn[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlt[31] wlt[30] wlt[29] wlt[28] hi
+ mid[7] issax2dec4
Xxdec4[6] c6saveb c6savet decvccb decvcct shclkb[3] shclkb[2] shclkb[1] shclkb[0]
+ shclkt[3] shclkt[2] shclkt[1] shclkt[0] slpen slpen vcc vssx wlb[27] wlb[26] wlb[25]
+ wlb[24] wle[3] wle[2] wle[1] wle[0] wle[3] wle[2] wle[1] wle[0] wllvlnn[2] wllvlnn[1]
+ wllvlnn[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlt[27] wlt[26] wlt[25] wlt[24] hi
+ mid[6] issax2dec4
Xxdec4[5] c6saveb c6savet decvccb decvcct shclkb[3] shclkb[2] shclkb[1] shclkb[0]
+ shclkt[3] shclkt[2] shclkt[1] shclkt[0] slpen slpen vcc vssx wlb[23] wlb[22] wlb[21]
+ wlb[20] wle[3] wle[2] wle[1] wle[0] wle[3] wle[2] wle[1] wle[0] wllvlnn[2] wllvlnn[1]
+ wllvlnn[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlt[23] wlt[22] wlt[21] wlt[20] hi
+ mid[5] issax2dec4
Xxdec4[4] c6saveb c6savet decvccb decvcct shclkb[3] shclkb[2] shclkb[1] shclkb[0]
+ shclkt[3] shclkt[2] shclkt[1] shclkt[0] slpen slpen vcc vssx wlb[19] wlb[18] wlb[17]
+ wlb[16] wle[3] wle[2] wle[1] wle[0] wle[3] wle[2] wle[1] wle[0] wllvlnn[2] wllvlnn[1]
+ wllvlnn[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlt[19] wlt[18] wlt[17] wlt[16] hi
+ mid[4] issax2dec4
Xxdec4[3] c6saveb c6savet decvccb decvcct shclkb[3] shclkb[2] shclkb[1] shclkb[0]
+ shclkt[3] shclkt[2] shclkt[1] shclkt[0] slpen slpen vcc vssx wlb[15] wlb[14] wlb[13]
+ wlb[12] wle[3] wle[2] wle[1] wle[0] wle[3] wle[2] wle[1] wle[0] wllvlnn[2] wllvlnn[1]
+ wllvlnn[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlt[15] wlt[14] wlt[13] wlt[12] hi
+ mid[3] issax2dec4
Xxdec4[2] c6saveb c6savet decvccb decvcct shclkb[3] shclkb[2] shclkb[1] shclkb[0]
+ shclkt[3] shclkt[2] shclkt[1] shclkt[0] slpen slpen vcc vssx wlb[11] wlb[10] wlb[9]
+ wlb[8] wle[3] wle[2] wle[1] wle[0] wle[3] wle[2] wle[1] wle[0] wllvlnn[2] wllvlnn[1]
+ wllvlnn[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlt[11] wlt[10] wlt[9] wlt[8] hi mid[2] issax2dec4
Xxdec4[1] c6saveb c6savet decvccb decvcct shclkb[3] shclkb[2] shclkb[1] shclkb[0]
+ shclkt[3] shclkt[2] shclkt[1] shclkt[0] slpen slpen vcc vssx wlb[7] wlb[6] wlb[5]
+ wlb[4] wle[3] wle[2] wle[1] wle[0] wle[3] wle[2] wle[1] wle[0] wllvlnn[2] wllvlnn[1]
+ wllvlnn[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlt[7] wlt[6] wlt[5] wlt[4] hi mid[1] issax2dec4
Xxdec4[0] c6saveb c6savet decvccb decvcct shclkb[3] shclkb[2] shclkb[1] shclkb[0]
+ shclkt[3] shclkt[2] shclkt[1] shclkt[0] slpen slpen vcc vssx wlb[3] wlb[2] wlb[1]
+ wlb[0] wle[3] wle[2] wle[1] wle[0] wle[3] wle[2] wle[1] wle[0] wllvlnn[2] wllvlnn[1]
+ wllvlnn[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlt[3] wlt[2] wlt[1] wlt[0] hi mid[0] issax2dec4
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccciocm4
* View Name:    schematic
************************************************************************
.SUBCKT issahccciocm4 decnvss idin inbl inblnn lyaenbit lyaennn nbl_kicknn ncg2 nvss
+ odout saenn sapchnn vcc vssx waenn[2] waenn[1] waenn[0] wrclk wrdata wrdataen
+ wrdatann
*.PININFO decnvss:O idin:I inbl:B inblnn:B lyaenbit:O lyaennn:I nbl_kicknn:I ncg2:O nvss:O odout:O saenn:I sapchnn:I vcc:I vssx:I waenn[2]:I waenn[1]:I waenn[0]:I wrclk:I wrdata:O wrdataen:I
*.PININFO wrdatann:O
Xsamp inbl inblnn odout saenn sapchnn vcc vssx issahcciosenseampnbl
Xwrdatadrv decnvss idin lyaenbit lyaennn nbl_kicknn ncg2 nvss vcc vssx waenn[2]
+ waenn[1] waenn[0] wrclk wrdata wrdatann wrdataen issahcciowrbfnbl
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_sramgiobank_up clkrdsync clkwr2h2l idin[66]
+ idin[65] idin[64] idin[63] idin[62] idin[61] idin[60] idin[59] idin[58] idin[57]
+ idin[56] idin[55] idin[54] idin[53] idin[52] idin[51] idin[50] idin[49] idin[48]
+ idin[47] idin[46] idin[45] idin[44] idin[43] idin[42] idin[41] idin[40] idin[39]
+ idin[38] idin[37] idin[36] idin[35] idin[34] idin[33] idin[32] idin[31] idin[30]
+ idin[29] idin[28] idin[27] idin[26] idin[25] idin[24] idin[23] idin[22] idin[21]
+ idin[20] idin[19] idin[18] idin[17] idin[16] idin[15] idin[14] idin[13] idin[12]
+ idin[11] idin[10] idin[9] idin[8] idin[7] idin[6] idin[5] idin[4] idin[3] idin[2]
+ idin[1] idin[0] idin1l[66] idin1l[65] idin1l[64] idin1l[63] idin1l[62] idin1l[61]
+ idin1l[60] idin1l[59] idin1l[58] idin1l[57] idin1l[56] idin1l[55] idin1l[54] idin1l[53]
+ idin1l[52] idin1l[51] idin1l[50] idin1l[49] idin1l[48] idin1l[47] idin1l[46] idin1l[45]
+ idin1l[44] idin1l[43] idin1l[42] idin1l[41] idin1l[40] idin1l[39] idin1l[38] idin1l[37]
+ idin1l[36] idin1l[35] idin1l[34] idin1l[33] idin1l[32] idin1l[31] idin1l[30] idin1l[29]
+ idin1l[28] idin1l[27] idin1l[26] idin1l[25] idin1l[24] idin1l[23] idin1l[22] idin1l[21]
+ idin1l[20] idin1l[19] idin1l[18] idin1l[17] idin1l[16] idin1l[15] idin1l[14] idin1l[13]
+ idin1l[12] idin1l[11] idin1l[10] idin1l[9] idin1l[8] idin1l[7] idin1l[6] idin1l[5]
+ idin1l[4] idin1l[3] idin1l[2] idin1l[1] idin1l[0] lyal0bl[66] lyal0bl[65] lyal0bl[64]
+ lyal0bl[63] lyal0bl[62] lyal0bl[61] lyal0bl[60] lyal0bl[59] lyal0bl[58] lyal0bl[57]
+ lyal0bl[56] lyal0bl[55] lyal0bl[54] lyal0bl[53] lyal0bl[52] lyal0bl[51] lyal0bl[50]
+ lyal0bl[49] lyal0bl[48] lyal0bl[47] lyal0bl[46] lyal0bl[45] lyal0bl[44] lyal0bl[43]
+ lyal0bl[42] lyal0bl[41] lyal0bl[40] lyal0bl[39] lyal0bl[38] lyal0bl[37] lyal0bl[36]
+ lyal0bl[35] lyal0bl[34] lyal0bl[33] lyal0bl[32] lyal0bl[31] lyal0bl[30] lyal0bl[29]
+ lyal0bl[28] lyal0bl[27] lyal0bl[26] lyal0bl[25] lyal0bl[24] lyal0bl[23] lyal0bl[22]
+ lyal0bl[21] lyal0bl[20] lyal0bl[19] lyal0bl[18] lyal0bl[17] lyal0bl[16] lyal0bl[15]
+ lyal0bl[14] lyal0bl[13] lyal0bl[12] lyal0bl[11] lyal0bl[10] lyal0bl[9] lyal0bl[8]
+ lyal0bl[7] lyal0bl[6] lyal0bl[5] lyal0bl[4] lyal0bl[3] lyal0bl[2] lyal0bl[1] lyal0bl[0]
+ lyal0blnn[66] lyal0blnn[65] lyal0blnn[64] lyal0blnn[63] lyal0blnn[62] lyal0blnn[61]
+ lyal0blnn[60] lyal0blnn[59] lyal0blnn[58] lyal0blnn[57] lyal0blnn[56] lyal0blnn[55]
+ lyal0blnn[54] lyal0blnn[53] lyal0blnn[52] lyal0blnn[51] lyal0blnn[50] lyal0blnn[49]
+ lyal0blnn[48] lyal0blnn[47] lyal0blnn[46] lyal0blnn[45] lyal0blnn[44] lyal0blnn[43]
+ lyal0blnn[42] lyal0blnn[41] lyal0blnn[40] lyal0blnn[39] lyal0blnn[38] lyal0blnn[37]
+ lyal0blnn[36] lyal0blnn[35] lyal0blnn[34] lyal0blnn[33] lyal0blnn[32] lyal0blnn[31]
+ lyal0blnn[30] lyal0blnn[29] lyal0blnn[28] lyal0blnn[27] lyal0blnn[26] lyal0blnn[25]
+ lyal0blnn[24] lyal0blnn[23] lyal0blnn[22] lyal0blnn[21] lyal0blnn[20] lyal0blnn[19]
+ lyal0blnn[18] lyal0blnn[17] lyal0blnn[16] lyal0blnn[15] lyal0blnn[14] lyal0blnn[13]
+ lyal0blnn[12] lyal0blnn[11] lyal0blnn[10] lyal0blnn[9] lyal0blnn[8] lyal0blnn[7]
+ lyal0blnn[6] lyal0blnn[5] lyal0blnn[4] lyal0blnn[3] lyal0blnn[2] lyal0blnn[1]
+ lyal0blnn[0] lyal1bl lyal1blnn lyasel odout[66] odout[65] odout[64] odout[63]
+ odout[62] odout[61] odout[60] odout[59] odout[58] odout[57] odout[56] odout[55]
+ odout[54] odout[53] odout[52] odout[51] odout[50] odout[49] odout[48] odout[47]
+ odout[46] odout[45] odout[44] odout[43] odout[42] odout[41] odout[40] odout[39]
+ odout[38] odout[37] odout[36] odout[35] odout[34] odout[33] odout[32] odout[31]
+ odout[30] odout[29] odout[28] odout[27] odout[26] odout[25] odout[24] odout[23]
+ odout[22] odout[21] odout[20] odout[19] odout[18] odout[17] odout[16] odout[15]
+ odout[14] odout[13] odout[12] odout[11] odout[10] odout[9] odout[8] odout[7] odout[6]
+ odout[5] odout[4] odout[3] odout[2] odout[1] odout[0] rddataout_0[66] rddataout_0[65]
+ rddataout_0[64] rddataout_0[63] rddataout_0[62] rddataout_0[61] rddataout_0[60]
+ rddataout_0[59] rddataout_0[58] rddataout_0[57] rddataout_0[56] rddataout_0[55]
+ rddataout_0[54] rddataout_0[53] rddataout_0[52] rddataout_0[51] rddataout_0[50]
+ rddataout_0[49] rddataout_0[48] rddataout_0[47] rddataout_0[46] rddataout_0[45]
+ rddataout_0[44] rddataout_0[43] rddataout_0[42] rddataout_0[41] rddataout_0[40]
+ rddataout_0[39] rddataout_0[38] rddataout_0[37] rddataout_0[36] rddataout_0[35]
+ rddataout_0[34] rddataout_0[33] rddataout_0[32] rddataout_0[31] rddataout_0[30]
+ rddataout_0[29] rddataout_0[28] rddataout_0[27] rddataout_0[26] rddataout_0[25]
+ rddataout_0[24] rddataout_0[23] rddataout_0[22] rddataout_0[21] rddataout_0[20]
+ rddataout_0[19] rddataout_0[18] rddataout_0[17] rddataout_0[16] rddataout_0[15]
+ rddataout_0[14] rddataout_0[13] rddataout_0[12] rddataout_0[11] rddataout_0[10]
+ rddataout_0[9] rddataout_0[8] rddataout_0[7] rddataout_0[6] rddataout_0[5] rddataout_0[4]
+ rddataout_0[3] rddataout_0[2] rddataout_0[1] rddataout_0[0] rddataout_1[66] rddataout_1[65]
+ rddataout_1[64] rddataout_1[63] rddataout_1[62] rddataout_1[61] rddataout_1[60]
+ rddataout_1[59] rddataout_1[58] rddataout_1[57] rddataout_1[56] rddataout_1[55]
+ rddataout_1[54] rddataout_1[53] rddataout_1[52] rddataout_1[51] rddataout_1[50]
+ rddataout_1[49] rddataout_1[48] rddataout_1[47] rddataout_1[46] rddataout_1[45]
+ rddataout_1[44] rddataout_1[43] rddataout_1[42] rddataout_1[41] rddataout_1[40]
+ rddataout_1[39] rddataout_1[38] rddataout_1[37] rddataout_1[36] rddataout_1[35]
+ rddataout_1[34] rddataout_1[33] rddataout_1[32] rddataout_1[31] rddataout_1[30]
+ rddataout_1[29] rddataout_1[28] rddataout_1[27] rddataout_1[26] rddataout_1[25]
+ rddataout_1[24] rddataout_1[23] rddataout_1[22] rddataout_1[21] rddataout_1[20]
+ rddataout_1[19] rddataout_1[18] rddataout_1[17] rddataout_1[16] rddataout_1[15]
+ rddataout_1[14] rddataout_1[13] rddataout_1[12] rddataout_1[11] rddataout_1[10]
+ rddataout_1[9] rddataout_1[8] rddataout_1[7] rddataout_1[6] rddataout_1[5] rddataout_1[4]
+ rddataout_1[3] rddataout_1[2] rddataout_1[1] rddataout_1[0] selbnk0nn selbnk1nn
+ vcc vss
*.PININFO clkrdsync:I clkwr2h2l:I idin[66]:I idin[65]:I idin[64]:I idin[63]:I idin[62]:I idin[61]:I idin[60]:I idin[59]:I idin[58]:I idin[57]:I idin[56]:I idin[55]:I idin[54]:I idin[53]:I idin[52]:I idin[51]:I idin[50]:I idin[49]:I
*.PININFO idin[48]:I idin[47]:I idin[46]:I idin[45]:I idin[44]:I idin[43]:I idin[42]:I idin[41]:I idin[40]:I idin[39]:I idin[38]:I idin[37]:I idin[36]:I idin[35]:I idin[34]:I idin[33]:I idin[32]:I idin[31]:I idin[30]:I idin[29]:I
*.PININFO idin[28]:I idin[27]:I idin[26]:I idin[25]:I idin[24]:I idin[23]:I idin[22]:I idin[21]:I idin[20]:I idin[19]:I idin[18]:I idin[17]:I idin[16]:I idin[15]:I idin[14]:I idin[13]:I idin[12]:I idin[11]:I idin[10]:I idin[9]:I
*.PININFO idin[8]:I idin[7]:I idin[6]:I idin[5]:I idin[4]:I idin[3]:I idin[2]:I idin[1]:I idin[0]:I idin1l[66]:O idin1l[65]:O idin1l[64]:O idin1l[63]:O idin1l[62]:O idin1l[61]:O idin1l[60]:O idin1l[59]:O idin1l[58]:O idin1l[57]:O idin1l[56]:O
*.PININFO idin1l[55]:O idin1l[54]:O idin1l[53]:O idin1l[52]:O idin1l[51]:O idin1l[50]:O idin1l[49]:O idin1l[48]:O idin1l[47]:O idin1l[46]:O idin1l[45]:O idin1l[44]:O idin1l[43]:O idin1l[42]:O idin1l[41]:O idin1l[40]:O idin1l[39]:O idin1l[38]:O idin1l[37]:O idin1l[36]:O
*.PININFO idin1l[35]:O idin1l[34]:O idin1l[33]:O idin1l[32]:O idin1l[31]:O idin1l[30]:O idin1l[29]:O idin1l[28]:O idin1l[27]:O idin1l[26]:O idin1l[25]:O idin1l[24]:O idin1l[23]:O idin1l[22]:O idin1l[21]:O idin1l[20]:O idin1l[19]:O idin1l[18]:O idin1l[17]:O idin1l[16]:O
*.PININFO idin1l[15]:O idin1l[14]:O idin1l[13]:O idin1l[12]:O idin1l[11]:O idin1l[10]:O idin1l[9]:O idin1l[8]:O idin1l[7]:O idin1l[6]:O idin1l[5]:O idin1l[4]:O idin1l[3]:O idin1l[2]:O idin1l[1]:O idin1l[0]:O lyal0bl[66]:O lyal0bl[65]:O lyal0bl[64]:O lyal0bl[63]:O
*.PININFO lyal0bl[62]:O lyal0bl[61]:O lyal0bl[60]:O lyal0bl[59]:O lyal0bl[58]:O lyal0bl[57]:O lyal0bl[56]:O lyal0bl[55]:O lyal0bl[54]:O lyal0bl[53]:O lyal0bl[52]:O lyal0bl[51]:O lyal0bl[50]:O lyal0bl[49]:O lyal0bl[48]:O lyal0bl[47]:O lyal0bl[46]:O lyal0bl[45]:O lyal0bl[44]:O lyal0bl[43]:O
*.PININFO lyal0bl[42]:O lyal0bl[41]:O lyal0bl[40]:O lyal0bl[39]:O lyal0bl[38]:O lyal0bl[37]:O lyal0bl[36]:O lyal0bl[35]:O lyal0bl[34]:O lyal0bl[33]:O lyal0bl[32]:O lyal0bl[31]:O lyal0bl[30]:O lyal0bl[29]:O lyal0bl[28]:O lyal0bl[27]:O lyal0bl[26]:O lyal0bl[25]:O lyal0bl[24]:O lyal0bl[23]:O
*.PININFO lyal0bl[22]:O lyal0bl[21]:O lyal0bl[20]:O lyal0bl[19]:O lyal0bl[18]:O lyal0bl[17]:O lyal0bl[16]:O lyal0bl[15]:O lyal0bl[14]:O lyal0bl[13]:O lyal0bl[12]:O lyal0bl[11]:O lyal0bl[10]:O lyal0bl[9]:O lyal0bl[8]:O lyal0bl[7]:O lyal0bl[6]:O lyal0bl[5]:O lyal0bl[4]:O lyal0bl[3]:O
*.PININFO lyal0bl[2]:O lyal0bl[1]:O lyal0bl[0]:O lyal0blnn[66]:O lyal0blnn[65]:O lyal0blnn[64]:O lyal0blnn[63]:O lyal0blnn[62]:O lyal0blnn[61]:O lyal0blnn[60]:O lyal0blnn[59]:O lyal0blnn[58]:O lyal0blnn[57]:O lyal0blnn[56]:O lyal0blnn[55]:O lyal0blnn[54]:O lyal0blnn[53]:O lyal0blnn[52]:O lyal0blnn[51]:O lyal0blnn[50]:O
*.PININFO lyal0blnn[49]:O lyal0blnn[48]:O lyal0blnn[47]:O lyal0blnn[46]:O lyal0blnn[45]:O lyal0blnn[44]:O lyal0blnn[43]:O lyal0blnn[42]:O lyal0blnn[41]:O lyal0blnn[40]:O lyal0blnn[39]:O lyal0blnn[38]:O lyal0blnn[37]:O lyal0blnn[36]:O lyal0blnn[35]:O lyal0blnn[34]:O lyal0blnn[33]:O lyal0blnn[32]:O lyal0blnn[31]:O lyal0blnn[30]:O
*.PININFO lyal0blnn[29]:O lyal0blnn[28]:O lyal0blnn[27]:O lyal0blnn[26]:O lyal0blnn[25]:O lyal0blnn[24]:O lyal0blnn[23]:O lyal0blnn[22]:O lyal0blnn[21]:O lyal0blnn[20]:O lyal0blnn[19]:O lyal0blnn[18]:O lyal0blnn[17]:O lyal0blnn[16]:O lyal0blnn[15]:O lyal0blnn[14]:O lyal0blnn[13]:O lyal0blnn[12]:O lyal0blnn[11]:O lyal0blnn[10]:O
*.PININFO lyal0blnn[9]:O lyal0blnn[8]:O lyal0blnn[7]:O lyal0blnn[6]:O lyal0blnn[5]:O lyal0blnn[4]:O lyal0blnn[3]:O lyal0blnn[2]:O lyal0blnn[1]:O lyal0blnn[0]:O lyal1bl:I lyal1blnn:I lyasel:I odout[66]:O odout[65]:O odout[64]:O odout[63]:O odout[62]:O odout[61]:O odout[60]:O
*.PININFO odout[59]:O odout[58]:O odout[57]:O odout[56]:O odout[55]:O odout[54]:O odout[53]:O odout[52]:O odout[51]:O odout[50]:O odout[49]:O odout[48]:O odout[47]:O odout[46]:O odout[45]:O odout[44]:O odout[43]:O odout[42]:O odout[41]:O odout[40]:O
*.PININFO odout[39]:O odout[38]:O odout[37]:O odout[36]:O odout[35]:O odout[34]:O odout[33]:O odout[32]:O odout[31]:O odout[30]:O odout[29]:O odout[28]:O odout[27]:O odout[26]:O odout[25]:O odout[24]:O odout[23]:O odout[22]:O odout[21]:O odout[20]:O
*.PININFO odout[19]:O odout[18]:O odout[17]:O odout[16]:O odout[15]:O odout[14]:O odout[13]:O odout[12]:O odout[11]:O odout[10]:O odout[9]:O odout[8]:O odout[7]:O odout[6]:O odout[5]:O odout[4]:O odout[3]:O odout[2]:O odout[1]:O odout[0]:O
*.PININFO rddataout_0[66]:I rddataout_0[65]:I rddataout_0[64]:I rddataout_0[63]:I rddataout_0[62]:I rddataout_0[61]:I rddataout_0[60]:I rddataout_0[59]:I rddataout_0[58]:I rddataout_0[57]:I rddataout_0[56]:I rddataout_0[55]:I rddataout_0[54]:I rddataout_0[53]:I rddataout_0[52]:I rddataout_0[51]:I rddataout_0[50]:I rddataout_0[49]:I rddataout_0[48]:I rddataout_0[47]:I
*.PININFO rddataout_0[46]:I rddataout_0[45]:I rddataout_0[44]:I rddataout_0[43]:I rddataout_0[42]:I rddataout_0[41]:I rddataout_0[40]:I rddataout_0[39]:I rddataout_0[38]:I rddataout_0[37]:I rddataout_0[36]:I rddataout_0[35]:I rddataout_0[34]:I rddataout_0[33]:I rddataout_0[32]:I rddataout_0[31]:I rddataout_0[30]:I rddataout_0[29]:I rddataout_0[28]:I rddataout_0[27]:I
*.PININFO rddataout_0[26]:I rddataout_0[25]:I rddataout_0[24]:I rddataout_0[23]:I rddataout_0[22]:I rddataout_0[21]:I rddataout_0[20]:I rddataout_0[19]:I rddataout_0[18]:I rddataout_0[17]:I rddataout_0[16]:I rddataout_0[15]:I rddataout_0[14]:I rddataout_0[13]:I rddataout_0[12]:I rddataout_0[11]:I rddataout_0[10]:I rddataout_0[9]:I rddataout_0[8]:I rddataout_0[7]:I
*.PININFO rddataout_0[6]:I rddataout_0[5]:I rddataout_0[4]:I rddataout_0[3]:I rddataout_0[2]:I rddataout_0[1]:I rddataout_0[0]:I rddataout_1[66]:I rddataout_1[65]:I rddataout_1[64]:I rddataout_1[63]:I rddataout_1[62]:I rddataout_1[61]:I rddataout_1[60]:I rddataout_1[59]:I rddataout_1[58]:I rddataout_1[57]:I rddataout_1[56]:I rddataout_1[55]:I rddataout_1[54]:I
*.PININFO rddataout_1[53]:I rddataout_1[52]:I rddataout_1[51]:I rddataout_1[50]:I rddataout_1[49]:I rddataout_1[48]:I rddataout_1[47]:I rddataout_1[46]:I rddataout_1[45]:I rddataout_1[44]:I rddataout_1[43]:I rddataout_1[42]:I rddataout_1[41]:I rddataout_1[40]:I rddataout_1[39]:I rddataout_1[38]:I rddataout_1[37]:I rddataout_1[36]:I rddataout_1[35]:I rddataout_1[34]:I
*.PININFO rddataout_1[33]:I rddataout_1[32]:I rddataout_1[31]:I rddataout_1[30]:I rddataout_1[29]:I rddataout_1[28]:I rddataout_1[27]:I rddataout_1[26]:I rddataout_1[25]:I rddataout_1[24]:I rddataout_1[23]:I rddataout_1[22]:I rddataout_1[21]:I rddataout_1[20]:I rddataout_1[19]:I rddataout_1[18]:I rddataout_1[17]:I rddataout_1[16]:I rddataout_1[15]:I rddataout_1[14]:I
*.PININFO rddataout_1[13]:I rddataout_1[12]:I rddataout_1[11]:I rddataout_1[10]:I rddataout_1[9]:I rddataout_1[8]:I rddataout_1[7]:I rddataout_1[6]:I rddataout_1[5]:I rddataout_1[4]:I rddataout_1[3]:I rddataout_1[2]:I rddataout_1[1]:I rddataout_1[0]:I selbnk0nn:I selbnk1nn:I vcc:I vss:I
Xgioslice[66] clkrdsync clkwr2h2l idin[66] idin1l[66] lyal0bl[66] lyal0blnn[66]
+ lyal1bl lyal1blnn lyasel odout[66] rddataout_0[66] rddataout_1[66] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[65] clkrdsync clkwr2h2l idin[65] idin1l[65] lyal0bl[65] lyal0blnn[65]
+ lyal1bl lyal1blnn lyasel odout[65] rddataout_0[65] rddataout_1[65] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[64] clkrdsync clkwr2h2l idin[64] idin1l[64] lyal0bl[64] lyal0blnn[64]
+ lyal1bl lyal1blnn lyasel odout[64] rddataout_0[64] rddataout_1[64] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[63] clkrdsync clkwr2h2l idin[63] idin1l[63] lyal0bl[63] lyal0blnn[63]
+ lyal1bl lyal1blnn lyasel odout[63] rddataout_0[63] rddataout_1[63] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[62] clkrdsync clkwr2h2l idin[62] idin1l[62] lyal0bl[62] lyal0blnn[62]
+ lyal1bl lyal1blnn lyasel odout[62] rddataout_0[62] rddataout_1[62] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[61] clkrdsync clkwr2h2l idin[61] idin1l[61] lyal0bl[61] lyal0blnn[61]
+ lyal1bl lyal1blnn lyasel odout[61] rddataout_0[61] rddataout_1[61] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[60] clkrdsync clkwr2h2l idin[60] idin1l[60] lyal0bl[60] lyal0blnn[60]
+ lyal1bl lyal1blnn lyasel odout[60] rddataout_0[60] rddataout_1[60] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[59] clkrdsync clkwr2h2l idin[59] idin1l[59] lyal0bl[59] lyal0blnn[59]
+ lyal1bl lyal1blnn lyasel odout[59] rddataout_0[59] rddataout_1[59] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[58] clkrdsync clkwr2h2l idin[58] idin1l[58] lyal0bl[58] lyal0blnn[58]
+ lyal1bl lyal1blnn lyasel odout[58] rddataout_0[58] rddataout_1[58] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[57] clkrdsync clkwr2h2l idin[57] idin1l[57] lyal0bl[57] lyal0blnn[57]
+ lyal1bl lyal1blnn lyasel odout[57] rddataout_0[57] rddataout_1[57] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[56] clkrdsync clkwr2h2l idin[56] idin1l[56] lyal0bl[56] lyal0blnn[56]
+ lyal1bl lyal1blnn lyasel odout[56] rddataout_0[56] rddataout_1[56] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[55] clkrdsync clkwr2h2l idin[55] idin1l[55] lyal0bl[55] lyal0blnn[55]
+ lyal1bl lyal1blnn lyasel odout[55] rddataout_0[55] rddataout_1[55] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[54] clkrdsync clkwr2h2l idin[54] idin1l[54] lyal0bl[54] lyal0blnn[54]
+ lyal1bl lyal1blnn lyasel odout[54] rddataout_0[54] rddataout_1[54] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[53] clkrdsync clkwr2h2l idin[53] idin1l[53] lyal0bl[53] lyal0blnn[53]
+ lyal1bl lyal1blnn lyasel odout[53] rddataout_0[53] rddataout_1[53] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[52] clkrdsync clkwr2h2l idin[52] idin1l[52] lyal0bl[52] lyal0blnn[52]
+ lyal1bl lyal1blnn lyasel odout[52] rddataout_0[52] rddataout_1[52] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[51] clkrdsync clkwr2h2l idin[51] idin1l[51] lyal0bl[51] lyal0blnn[51]
+ lyal1bl lyal1blnn lyasel odout[51] rddataout_0[51] rddataout_1[51] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[50] clkrdsync clkwr2h2l idin[50] idin1l[50] lyal0bl[50] lyal0blnn[50]
+ lyal1bl lyal1blnn lyasel odout[50] rddataout_0[50] rddataout_1[50] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[49] clkrdsync clkwr2h2l idin[49] idin1l[49] lyal0bl[49] lyal0blnn[49]
+ lyal1bl lyal1blnn lyasel odout[49] rddataout_0[49] rddataout_1[49] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[48] clkrdsync clkwr2h2l idin[48] idin1l[48] lyal0bl[48] lyal0blnn[48]
+ lyal1bl lyal1blnn lyasel odout[48] rddataout_0[48] rddataout_1[48] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[47] clkrdsync clkwr2h2l idin[47] idin1l[47] lyal0bl[47] lyal0blnn[47]
+ lyal1bl lyal1blnn lyasel odout[47] rddataout_0[47] rddataout_1[47] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[46] clkrdsync clkwr2h2l idin[46] idin1l[46] lyal0bl[46] lyal0blnn[46]
+ lyal1bl lyal1blnn lyasel odout[46] rddataout_0[46] rddataout_1[46] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[45] clkrdsync clkwr2h2l idin[45] idin1l[45] lyal0bl[45] lyal0blnn[45]
+ lyal1bl lyal1blnn lyasel odout[45] rddataout_0[45] rddataout_1[45] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[44] clkrdsync clkwr2h2l idin[44] idin1l[44] lyal0bl[44] lyal0blnn[44]
+ lyal1bl lyal1blnn lyasel odout[44] rddataout_0[44] rddataout_1[44] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[43] clkrdsync clkwr2h2l idin[43] idin1l[43] lyal0bl[43] lyal0blnn[43]
+ lyal1bl lyal1blnn lyasel odout[43] rddataout_0[43] rddataout_1[43] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[42] clkrdsync clkwr2h2l idin[42] idin1l[42] lyal0bl[42] lyal0blnn[42]
+ lyal1bl lyal1blnn lyasel odout[42] rddataout_0[42] rddataout_1[42] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[41] clkrdsync clkwr2h2l idin[41] idin1l[41] lyal0bl[41] lyal0blnn[41]
+ lyal1bl lyal1blnn lyasel odout[41] rddataout_0[41] rddataout_1[41] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[40] clkrdsync clkwr2h2l idin[40] idin1l[40] lyal0bl[40] lyal0blnn[40]
+ lyal1bl lyal1blnn lyasel odout[40] rddataout_0[40] rddataout_1[40] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[39] clkrdsync clkwr2h2l idin[39] idin1l[39] lyal0bl[39] lyal0blnn[39]
+ lyal1bl lyal1blnn lyasel odout[39] rddataout_0[39] rddataout_1[39] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[38] clkrdsync clkwr2h2l idin[38] idin1l[38] lyal0bl[38] lyal0blnn[38]
+ lyal1bl lyal1blnn lyasel odout[38] rddataout_0[38] rddataout_1[38] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[37] clkrdsync clkwr2h2l idin[37] idin1l[37] lyal0bl[37] lyal0blnn[37]
+ lyal1bl lyal1blnn lyasel odout[37] rddataout_0[37] rddataout_1[37] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[36] clkrdsync clkwr2h2l idin[36] idin1l[36] lyal0bl[36] lyal0blnn[36]
+ lyal1bl lyal1blnn lyasel odout[36] rddataout_0[36] rddataout_1[36] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[35] clkrdsync clkwr2h2l idin[35] idin1l[35] lyal0bl[35] lyal0blnn[35]
+ lyal1bl lyal1blnn lyasel odout[35] rddataout_0[35] rddataout_1[35] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[34] clkrdsync clkwr2h2l idin[34] idin1l[34] lyal0bl[34] lyal0blnn[34]
+ lyal1bl lyal1blnn lyasel odout[34] rddataout_0[34] rddataout_1[34] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[33] clkrdsync clkwr2h2l idin[33] idin1l[33] lyal0bl[33] lyal0blnn[33]
+ lyal1bl lyal1blnn lyasel odout[33] rddataout_0[33] rddataout_1[33] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[32] clkrdsync clkwr2h2l idin[32] idin1l[32] lyal0bl[32] lyal0blnn[32]
+ lyal1bl lyal1blnn lyasel odout[32] rddataout_0[32] rddataout_1[32] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[31] clkrdsync clkwr2h2l idin[31] idin1l[31] lyal0bl[31] lyal0blnn[31]
+ lyal1bl lyal1blnn lyasel odout[31] rddataout_0[31] rddataout_1[31] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[30] clkrdsync clkwr2h2l idin[30] idin1l[30] lyal0bl[30] lyal0blnn[30]
+ lyal1bl lyal1blnn lyasel odout[30] rddataout_0[30] rddataout_1[30] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[29] clkrdsync clkwr2h2l idin[29] idin1l[29] lyal0bl[29] lyal0blnn[29]
+ lyal1bl lyal1blnn lyasel odout[29] rddataout_0[29] rddataout_1[29] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[28] clkrdsync clkwr2h2l idin[28] idin1l[28] lyal0bl[28] lyal0blnn[28]
+ lyal1bl lyal1blnn lyasel odout[28] rddataout_0[28] rddataout_1[28] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[27] clkrdsync clkwr2h2l idin[27] idin1l[27] lyal0bl[27] lyal0blnn[27]
+ lyal1bl lyal1blnn lyasel odout[27] rddataout_0[27] rddataout_1[27] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[26] clkrdsync clkwr2h2l idin[26] idin1l[26] lyal0bl[26] lyal0blnn[26]
+ lyal1bl lyal1blnn lyasel odout[26] rddataout_0[26] rddataout_1[26] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[25] clkrdsync clkwr2h2l idin[25] idin1l[25] lyal0bl[25] lyal0blnn[25]
+ lyal1bl lyal1blnn lyasel odout[25] rddataout_0[25] rddataout_1[25] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[24] clkrdsync clkwr2h2l idin[24] idin1l[24] lyal0bl[24] lyal0blnn[24]
+ lyal1bl lyal1blnn lyasel odout[24] rddataout_0[24] rddataout_1[24] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[23] clkrdsync clkwr2h2l idin[23] idin1l[23] lyal0bl[23] lyal0blnn[23]
+ lyal1bl lyal1blnn lyasel odout[23] rddataout_0[23] rddataout_1[23] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[22] clkrdsync clkwr2h2l idin[22] idin1l[22] lyal0bl[22] lyal0blnn[22]
+ lyal1bl lyal1blnn lyasel odout[22] rddataout_0[22] rddataout_1[22] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[21] clkrdsync clkwr2h2l idin[21] idin1l[21] lyal0bl[21] lyal0blnn[21]
+ lyal1bl lyal1blnn lyasel odout[21] rddataout_0[21] rddataout_1[21] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[20] clkrdsync clkwr2h2l idin[20] idin1l[20] lyal0bl[20] lyal0blnn[20]
+ lyal1bl lyal1blnn lyasel odout[20] rddataout_0[20] rddataout_1[20] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[19] clkrdsync clkwr2h2l idin[19] idin1l[19] lyal0bl[19] lyal0blnn[19]
+ lyal1bl lyal1blnn lyasel odout[19] rddataout_0[19] rddataout_1[19] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[18] clkrdsync clkwr2h2l idin[18] idin1l[18] lyal0bl[18] lyal0blnn[18]
+ lyal1bl lyal1blnn lyasel odout[18] rddataout_0[18] rddataout_1[18] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[17] clkrdsync clkwr2h2l idin[17] idin1l[17] lyal0bl[17] lyal0blnn[17]
+ lyal1bl lyal1blnn lyasel odout[17] rddataout_0[17] rddataout_1[17] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[16] clkrdsync clkwr2h2l idin[16] idin1l[16] lyal0bl[16] lyal0blnn[16]
+ lyal1bl lyal1blnn lyasel odout[16] rddataout_0[16] rddataout_1[16] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[15] clkrdsync clkwr2h2l idin[15] idin1l[15] lyal0bl[15] lyal0blnn[15]
+ lyal1bl lyal1blnn lyasel odout[15] rddataout_0[15] rddataout_1[15] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[14] clkrdsync clkwr2h2l idin[14] idin1l[14] lyal0bl[14] lyal0blnn[14]
+ lyal1bl lyal1blnn lyasel odout[14] rddataout_0[14] rddataout_1[14] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[13] clkrdsync clkwr2h2l idin[13] idin1l[13] lyal0bl[13] lyal0blnn[13]
+ lyal1bl lyal1blnn lyasel odout[13] rddataout_0[13] rddataout_1[13] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[12] clkrdsync clkwr2h2l idin[12] idin1l[12] lyal0bl[12] lyal0blnn[12]
+ lyal1bl lyal1blnn lyasel odout[12] rddataout_0[12] rddataout_1[12] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[11] clkrdsync clkwr2h2l idin[11] idin1l[11] lyal0bl[11] lyal0blnn[11]
+ lyal1bl lyal1blnn lyasel odout[11] rddataout_0[11] rddataout_1[11] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[10] clkrdsync clkwr2h2l idin[10] idin1l[10] lyal0bl[10] lyal0blnn[10]
+ lyal1bl lyal1blnn lyasel odout[10] rddataout_0[10] rddataout_1[10] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[9] clkrdsync clkwr2h2l idin[9] idin1l[9] lyal0bl[9] lyal0blnn[9] lyal1bl
+ lyal1blnn lyasel odout[9] rddataout_0[9] rddataout_1[9] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[8] clkrdsync clkwr2h2l idin[8] idin1l[8] lyal0bl[8] lyal0blnn[8] lyal1bl
+ lyal1blnn lyasel odout[8] rddataout_0[8] rddataout_1[8] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[7] clkrdsync clkwr2h2l idin[7] idin1l[7] lyal0bl[7] lyal0blnn[7] lyal1bl
+ lyal1blnn lyasel odout[7] rddataout_0[7] rddataout_1[7] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[6] clkrdsync clkwr2h2l idin[6] idin1l[6] lyal0bl[6] lyal0blnn[6] lyal1bl
+ lyal1blnn lyasel odout[6] rddataout_0[6] rddataout_1[6] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[5] clkrdsync clkwr2h2l idin[5] idin1l[5] lyal0bl[5] lyal0blnn[5] lyal1bl
+ lyal1blnn lyasel odout[5] rddataout_0[5] rddataout_1[5] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[4] clkrdsync clkwr2h2l idin[4] idin1l[4] lyal0bl[4] lyal0blnn[4] lyal1bl
+ lyal1blnn lyasel odout[4] rddataout_0[4] rddataout_1[4] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[3] clkrdsync clkwr2h2l idin[3] idin1l[3] lyal0bl[3] lyal0blnn[3] lyal1bl
+ lyal1blnn lyasel odout[3] rddataout_0[3] rddataout_1[3] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[2] clkrdsync clkwr2h2l idin[2] idin1l[2] lyal0bl[2] lyal0blnn[2] lyal1bl
+ lyal1blnn lyasel odout[2] rddataout_0[2] rddataout_1[2] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[1] clkrdsync clkwr2h2l idin[1] idin1l[1] lyal0bl[1] lyal0blnn[1] lyal1bl
+ lyal1blnn lyasel odout[1] rddataout_0[1] rddataout_1[1] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[0] clkrdsync clkwr2h2l idin[0] idin1l[0] lyal0bl[0] lyal0blnn[0] lyal1bl
+ lyal1blnn lyasel odout[0] rddataout_0[0] rddataout_1[0] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_sramgiobank_dn clkrdsync clkwr2h2l idin[67]
+ idin[66] idin[65] idin[64] idin[63] idin[62] idin[61] idin[60] idin[59] idin[58]
+ idin[57] idin[56] idin[55] idin[54] idin[53] idin[52] idin[51] idin[50] idin[49]
+ idin[48] idin[47] idin[46] idin[45] idin[44] idin[43] idin[42] idin[41] idin[40]
+ idin[39] idin[38] idin[37] idin[36] idin[35] idin[34] idin[33] idin[32] idin[31]
+ idin[30] idin[29] idin[28] idin[27] idin[26] idin[25] idin[24] idin[23] idin[22]
+ idin[21] idin[20] idin[19] idin[18] idin[17] idin[16] idin[15] idin[14] idin[13]
+ idin[12] idin[11] idin[10] idin[9] idin[8] idin[7] idin[6] idin[5] idin[4] idin[3]
+ idin[2] idin[1] idin[0] idin1l[67] idin1l[66] idin1l[65] idin1l[64] idin1l[63]
+ idin1l[62] idin1l[61] idin1l[60] idin1l[59] idin1l[58] idin1l[57] idin1l[56] idin1l[55]
+ idin1l[54] idin1l[53] idin1l[52] idin1l[51] idin1l[50] idin1l[49] idin1l[48] idin1l[47]
+ idin1l[46] idin1l[45] idin1l[44] idin1l[43] idin1l[42] idin1l[41] idin1l[40] idin1l[39]
+ idin1l[38] idin1l[37] idin1l[36] idin1l[35] idin1l[34] idin1l[33] idin1l[32] idin1l[31]
+ idin1l[30] idin1l[29] idin1l[28] idin1l[27] idin1l[26] idin1l[25] idin1l[24] idin1l[23]
+ idin1l[22] idin1l[21] idin1l[20] idin1l[19] idin1l[18] idin1l[17] idin1l[16] idin1l[15]
+ idin1l[14] idin1l[13] idin1l[12] idin1l[11] idin1l[10] idin1l[9] idin1l[8] idin1l[7]
+ idin1l[6] idin1l[5] idin1l[4] idin1l[3] idin1l[2] idin1l[1] idin1l[0] lyal0bl[67]
+ lyal0bl[66] lyal0bl[65] lyal0bl[64] lyal0bl[63] lyal0bl[62] lyal0bl[61] lyal0bl[60]
+ lyal0bl[59] lyal0bl[58] lyal0bl[57] lyal0bl[56] lyal0bl[55] lyal0bl[54] lyal0bl[53]
+ lyal0bl[52] lyal0bl[51] lyal0bl[50] lyal0bl[49] lyal0bl[48] lyal0bl[47] lyal0bl[46]
+ lyal0bl[45] lyal0bl[44] lyal0bl[43] lyal0bl[42] lyal0bl[41] lyal0bl[40] lyal0bl[39]
+ lyal0bl[38] lyal0bl[37] lyal0bl[36] lyal0bl[35] lyal0bl[34] lyal0bl[33] lyal0bl[32]
+ lyal0bl[31] lyal0bl[30] lyal0bl[29] lyal0bl[28] lyal0bl[27] lyal0bl[26] lyal0bl[25]
+ lyal0bl[24] lyal0bl[23] lyal0bl[22] lyal0bl[21] lyal0bl[20] lyal0bl[19] lyal0bl[18]
+ lyal0bl[17] lyal0bl[16] lyal0bl[15] lyal0bl[14] lyal0bl[13] lyal0bl[12] lyal0bl[11]
+ lyal0bl[10] lyal0bl[9] lyal0bl[8] lyal0bl[7] lyal0bl[6] lyal0bl[5] lyal0bl[4]
+ lyal0bl[3] lyal0bl[2] lyal0bl[1] lyal0bl[0] lyal0blnn[67] lyal0blnn[66] lyal0blnn[65]
+ lyal0blnn[64] lyal0blnn[63] lyal0blnn[62] lyal0blnn[61] lyal0blnn[60] lyal0blnn[59]
+ lyal0blnn[58] lyal0blnn[57] lyal0blnn[56] lyal0blnn[55] lyal0blnn[54] lyal0blnn[53]
+ lyal0blnn[52] lyal0blnn[51] lyal0blnn[50] lyal0blnn[49] lyal0blnn[48] lyal0blnn[47]
+ lyal0blnn[46] lyal0blnn[45] lyal0blnn[44] lyal0blnn[43] lyal0blnn[42] lyal0blnn[41]
+ lyal0blnn[40] lyal0blnn[39] lyal0blnn[38] lyal0blnn[37] lyal0blnn[36] lyal0blnn[35]
+ lyal0blnn[34] lyal0blnn[33] lyal0blnn[32] lyal0blnn[31] lyal0blnn[30] lyal0blnn[29]
+ lyal0blnn[28] lyal0blnn[27] lyal0blnn[26] lyal0blnn[25] lyal0blnn[24] lyal0blnn[23]
+ lyal0blnn[22] lyal0blnn[21] lyal0blnn[20] lyal0blnn[19] lyal0blnn[18] lyal0blnn[17]
+ lyal0blnn[16] lyal0blnn[15] lyal0blnn[14] lyal0blnn[13] lyal0blnn[12] lyal0blnn[11]
+ lyal0blnn[10] lyal0blnn[9] lyal0blnn[8] lyal0blnn[7] lyal0blnn[6] lyal0blnn[5]
+ lyal0blnn[4] lyal0blnn[3] lyal0blnn[2] lyal0blnn[1] lyal0blnn[0] lyal1bl lyal1blnn
+ lyasel odout[67] odout[66] odout[65] odout[64] odout[63] odout[62] odout[61] odout[60]
+ odout[59] odout[58] odout[57] odout[56] odout[55] odout[54] odout[53] odout[52]
+ odout[51] odout[50] odout[49] odout[48] odout[47] odout[46] odout[45] odout[44]
+ odout[43] odout[42] odout[41] odout[40] odout[39] odout[38] odout[37] odout[36]
+ odout[35] odout[34] odout[33] odout[32] odout[31] odout[30] odout[29] odout[28]
+ odout[27] odout[26] odout[25] odout[24] odout[23] odout[22] odout[21] odout[20]
+ odout[19] odout[18] odout[17] odout[16] odout[15] odout[14] odout[13] odout[12]
+ odout[11] odout[10] odout[9] odout[8] odout[7] odout[6] odout[5] odout[4] odout[3]
+ odout[2] odout[1] odout[0] rddataout_0[67] rddataout_0[66] rddataout_0[65] rddataout_0[64]
+ rddataout_0[63] rddataout_0[62] rddataout_0[61] rddataout_0[60] rddataout_0[59]
+ rddataout_0[58] rddataout_0[57] rddataout_0[56] rddataout_0[55] rddataout_0[54]
+ rddataout_0[53] rddataout_0[52] rddataout_0[51] rddataout_0[50] rddataout_0[49]
+ rddataout_0[48] rddataout_0[47] rddataout_0[46] rddataout_0[45] rddataout_0[44]
+ rddataout_0[43] rddataout_0[42] rddataout_0[41] rddataout_0[40] rddataout_0[39]
+ rddataout_0[38] rddataout_0[37] rddataout_0[36] rddataout_0[35] rddataout_0[34]
+ rddataout_0[33] rddataout_0[32] rddataout_0[31] rddataout_0[30] rddataout_0[29]
+ rddataout_0[28] rddataout_0[27] rddataout_0[26] rddataout_0[25] rddataout_0[24]
+ rddataout_0[23] rddataout_0[22] rddataout_0[21] rddataout_0[20] rddataout_0[19]
+ rddataout_0[18] rddataout_0[17] rddataout_0[16] rddataout_0[15] rddataout_0[14]
+ rddataout_0[13] rddataout_0[12] rddataout_0[11] rddataout_0[10] rddataout_0[9]
+ rddataout_0[8] rddataout_0[7] rddataout_0[6] rddataout_0[5] rddataout_0[4] rddataout_0[3]
+ rddataout_0[2] rddataout_0[1] rddataout_0[0] rddataout_1[67] rddataout_1[66] rddataout_1[65]
+ rddataout_1[64] rddataout_1[63] rddataout_1[62] rddataout_1[61] rddataout_1[60]
+ rddataout_1[59] rddataout_1[58] rddataout_1[57] rddataout_1[56] rddataout_1[55]
+ rddataout_1[54] rddataout_1[53] rddataout_1[52] rddataout_1[51] rddataout_1[50]
+ rddataout_1[49] rddataout_1[48] rddataout_1[47] rddataout_1[46] rddataout_1[45]
+ rddataout_1[44] rddataout_1[43] rddataout_1[42] rddataout_1[41] rddataout_1[40]
+ rddataout_1[39] rddataout_1[38] rddataout_1[37] rddataout_1[36] rddataout_1[35]
+ rddataout_1[34] rddataout_1[33] rddataout_1[32] rddataout_1[31] rddataout_1[30]
+ rddataout_1[29] rddataout_1[28] rddataout_1[27] rddataout_1[26] rddataout_1[25]
+ rddataout_1[24] rddataout_1[23] rddataout_1[22] rddataout_1[21] rddataout_1[20]
+ rddataout_1[19] rddataout_1[18] rddataout_1[17] rddataout_1[16] rddataout_1[15]
+ rddataout_1[14] rddataout_1[13] rddataout_1[12] rddataout_1[11] rddataout_1[10]
+ rddataout_1[9] rddataout_1[8] rddataout_1[7] rddataout_1[6] rddataout_1[5] rddataout_1[4]
+ rddataout_1[3] rddataout_1[2] rddataout_1[1] rddataout_1[0] selbnk0nn selbnk1nn
+ vcc vss
*.PININFO clkrdsync:I clkwr2h2l:I idin[67]:I idin[66]:I idin[65]:I idin[64]:I idin[63]:I idin[62]:I idin[61]:I idin[60]:I idin[59]:I idin[58]:I idin[57]:I idin[56]:I idin[55]:I idin[54]:I idin[53]:I idin[52]:I idin[51]:I idin[50]:I
*.PININFO idin[49]:I idin[48]:I idin[47]:I idin[46]:I idin[45]:I idin[44]:I idin[43]:I idin[42]:I idin[41]:I idin[40]:I idin[39]:I idin[38]:I idin[37]:I idin[36]:I idin[35]:I idin[34]:I idin[33]:I idin[32]:I idin[31]:I idin[30]:I
*.PININFO idin[29]:I idin[28]:I idin[27]:I idin[26]:I idin[25]:I idin[24]:I idin[23]:I idin[22]:I idin[21]:I idin[20]:I idin[19]:I idin[18]:I idin[17]:I idin[16]:I idin[15]:I idin[14]:I idin[13]:I idin[12]:I idin[11]:I idin[10]:I
*.PININFO idin[9]:I idin[8]:I idin[7]:I idin[6]:I idin[5]:I idin[4]:I idin[3]:I idin[2]:I idin[1]:I idin[0]:I idin1l[67]:O idin1l[66]:O idin1l[65]:O idin1l[64]:O idin1l[63]:O idin1l[62]:O idin1l[61]:O idin1l[60]:O idin1l[59]:O idin1l[58]:O
*.PININFO idin1l[57]:O idin1l[56]:O idin1l[55]:O idin1l[54]:O idin1l[53]:O idin1l[52]:O idin1l[51]:O idin1l[50]:O idin1l[49]:O idin1l[48]:O idin1l[47]:O idin1l[46]:O idin1l[45]:O idin1l[44]:O idin1l[43]:O idin1l[42]:O idin1l[41]:O idin1l[40]:O idin1l[39]:O idin1l[38]:O
*.PININFO idin1l[37]:O idin1l[36]:O idin1l[35]:O idin1l[34]:O idin1l[33]:O idin1l[32]:O idin1l[31]:O idin1l[30]:O idin1l[29]:O idin1l[28]:O idin1l[27]:O idin1l[26]:O idin1l[25]:O idin1l[24]:O idin1l[23]:O idin1l[22]:O idin1l[21]:O idin1l[20]:O idin1l[19]:O idin1l[18]:O
*.PININFO idin1l[17]:O idin1l[16]:O idin1l[15]:O idin1l[14]:O idin1l[13]:O idin1l[12]:O idin1l[11]:O idin1l[10]:O idin1l[9]:O idin1l[8]:O idin1l[7]:O idin1l[6]:O idin1l[5]:O idin1l[4]:O idin1l[3]:O idin1l[2]:O idin1l[1]:O idin1l[0]:O lyal0bl[67]:O lyal0bl[66]:O
*.PININFO lyal0bl[65]:O lyal0bl[64]:O lyal0bl[63]:O lyal0bl[62]:O lyal0bl[61]:O lyal0bl[60]:O lyal0bl[59]:O lyal0bl[58]:O lyal0bl[57]:O lyal0bl[56]:O lyal0bl[55]:O lyal0bl[54]:O lyal0bl[53]:O lyal0bl[52]:O lyal0bl[51]:O lyal0bl[50]:O lyal0bl[49]:O lyal0bl[48]:O lyal0bl[47]:O lyal0bl[46]:O
*.PININFO lyal0bl[45]:O lyal0bl[44]:O lyal0bl[43]:O lyal0bl[42]:O lyal0bl[41]:O lyal0bl[40]:O lyal0bl[39]:O lyal0bl[38]:O lyal0bl[37]:O lyal0bl[36]:O lyal0bl[35]:O lyal0bl[34]:O lyal0bl[33]:O lyal0bl[32]:O lyal0bl[31]:O lyal0bl[30]:O lyal0bl[29]:O lyal0bl[28]:O lyal0bl[27]:O lyal0bl[26]:O
*.PININFO lyal0bl[25]:O lyal0bl[24]:O lyal0bl[23]:O lyal0bl[22]:O lyal0bl[21]:O lyal0bl[20]:O lyal0bl[19]:O lyal0bl[18]:O lyal0bl[17]:O lyal0bl[16]:O lyal0bl[15]:O lyal0bl[14]:O lyal0bl[13]:O lyal0bl[12]:O lyal0bl[11]:O lyal0bl[10]:O lyal0bl[9]:O lyal0bl[8]:O lyal0bl[7]:O lyal0bl[6]:O
*.PININFO lyal0bl[5]:O lyal0bl[4]:O lyal0bl[3]:O lyal0bl[2]:O lyal0bl[1]:O lyal0bl[0]:O lyal0blnn[67]:O lyal0blnn[66]:O lyal0blnn[65]:O lyal0blnn[64]:O lyal0blnn[63]:O lyal0blnn[62]:O lyal0blnn[61]:O lyal0blnn[60]:O lyal0blnn[59]:O lyal0blnn[58]:O lyal0blnn[57]:O lyal0blnn[56]:O lyal0blnn[55]:O lyal0blnn[54]:O
*.PININFO lyal0blnn[53]:O lyal0blnn[52]:O lyal0blnn[51]:O lyal0blnn[50]:O lyal0blnn[49]:O lyal0blnn[48]:O lyal0blnn[47]:O lyal0blnn[46]:O lyal0blnn[45]:O lyal0blnn[44]:O lyal0blnn[43]:O lyal0blnn[42]:O lyal0blnn[41]:O lyal0blnn[40]:O lyal0blnn[39]:O lyal0blnn[38]:O lyal0blnn[37]:O lyal0blnn[36]:O lyal0blnn[35]:O lyal0blnn[34]:O
*.PININFO lyal0blnn[33]:O lyal0blnn[32]:O lyal0blnn[31]:O lyal0blnn[30]:O lyal0blnn[29]:O lyal0blnn[28]:O lyal0blnn[27]:O lyal0blnn[26]:O lyal0blnn[25]:O lyal0blnn[24]:O lyal0blnn[23]:O lyal0blnn[22]:O lyal0blnn[21]:O lyal0blnn[20]:O lyal0blnn[19]:O lyal0blnn[18]:O lyal0blnn[17]:O lyal0blnn[16]:O lyal0blnn[15]:O lyal0blnn[14]:O
*.PININFO lyal0blnn[13]:O lyal0blnn[12]:O lyal0blnn[11]:O lyal0blnn[10]:O lyal0blnn[9]:O lyal0blnn[8]:O lyal0blnn[7]:O lyal0blnn[6]:O lyal0blnn[5]:O lyal0blnn[4]:O lyal0blnn[3]:O lyal0blnn[2]:O lyal0blnn[1]:O lyal0blnn[0]:O lyal1bl:I lyal1blnn:I lyasel:I odout[67]:O odout[66]:O odout[65]:O
*.PININFO odout[64]:O odout[63]:O odout[62]:O odout[61]:O odout[60]:O odout[59]:O odout[58]:O odout[57]:O odout[56]:O odout[55]:O odout[54]:O odout[53]:O odout[52]:O odout[51]:O odout[50]:O odout[49]:O odout[48]:O odout[47]:O odout[46]:O odout[45]:O
*.PININFO odout[44]:O odout[43]:O odout[42]:O odout[41]:O odout[40]:O odout[39]:O odout[38]:O odout[37]:O odout[36]:O odout[35]:O odout[34]:O odout[33]:O odout[32]:O odout[31]:O odout[30]:O odout[29]:O odout[28]:O odout[27]:O odout[26]:O odout[25]:O
*.PININFO odout[24]:O odout[23]:O odout[22]:O odout[21]:O odout[20]:O odout[19]:O odout[18]:O odout[17]:O odout[16]:O odout[15]:O odout[14]:O odout[13]:O odout[12]:O odout[11]:O odout[10]:O odout[9]:O odout[8]:O odout[7]:O odout[6]:O odout[5]:O
*.PININFO odout[4]:O odout[3]:O odout[2]:O odout[1]:O odout[0]:O rddataout_0[67]:I rddataout_0[66]:I rddataout_0[65]:I rddataout_0[64]:I rddataout_0[63]:I rddataout_0[62]:I rddataout_0[61]:I rddataout_0[60]:I rddataout_0[59]:I rddataout_0[58]:I rddataout_0[57]:I rddataout_0[56]:I rddataout_0[55]:I rddataout_0[54]:I rddataout_0[53]:I
*.PININFO rddataout_0[52]:I rddataout_0[51]:I rddataout_0[50]:I rddataout_0[49]:I rddataout_0[48]:I rddataout_0[47]:I rddataout_0[46]:I rddataout_0[45]:I rddataout_0[44]:I rddataout_0[43]:I rddataout_0[42]:I rddataout_0[41]:I rddataout_0[40]:I rddataout_0[39]:I rddataout_0[38]:I rddataout_0[37]:I rddataout_0[36]:I rddataout_0[35]:I rddataout_0[34]:I rddataout_0[33]:I
*.PININFO rddataout_0[32]:I rddataout_0[31]:I rddataout_0[30]:I rddataout_0[29]:I rddataout_0[28]:I rddataout_0[27]:I rddataout_0[26]:I rddataout_0[25]:I rddataout_0[24]:I rddataout_0[23]:I rddataout_0[22]:I rddataout_0[21]:I rddataout_0[20]:I rddataout_0[19]:I rddataout_0[18]:I rddataout_0[17]:I rddataout_0[16]:I rddataout_0[15]:I rddataout_0[14]:I rddataout_0[13]:I
*.PININFO rddataout_0[12]:I rddataout_0[11]:I rddataout_0[10]:I rddataout_0[9]:I rddataout_0[8]:I rddataout_0[7]:I rddataout_0[6]:I rddataout_0[5]:I rddataout_0[4]:I rddataout_0[3]:I rddataout_0[2]:I rddataout_0[1]:I rddataout_0[0]:I rddataout_1[67]:I rddataout_1[66]:I rddataout_1[65]:I rddataout_1[64]:I rddataout_1[63]:I rddataout_1[62]:I rddataout_1[61]:I
*.PININFO rddataout_1[60]:I rddataout_1[59]:I rddataout_1[58]:I rddataout_1[57]:I rddataout_1[56]:I rddataout_1[55]:I rddataout_1[54]:I rddataout_1[53]:I rddataout_1[52]:I rddataout_1[51]:I rddataout_1[50]:I rddataout_1[49]:I rddataout_1[48]:I rddataout_1[47]:I rddataout_1[46]:I rddataout_1[45]:I rddataout_1[44]:I rddataout_1[43]:I rddataout_1[42]:I rddataout_1[41]:I
*.PININFO rddataout_1[40]:I rddataout_1[39]:I rddataout_1[38]:I rddataout_1[37]:I rddataout_1[36]:I rddataout_1[35]:I rddataout_1[34]:I rddataout_1[33]:I rddataout_1[32]:I rddataout_1[31]:I rddataout_1[30]:I rddataout_1[29]:I rddataout_1[28]:I rddataout_1[27]:I rddataout_1[26]:I rddataout_1[25]:I rddataout_1[24]:I rddataout_1[23]:I rddataout_1[22]:I rddataout_1[21]:I
*.PININFO rddataout_1[20]:I rddataout_1[19]:I rddataout_1[18]:I rddataout_1[17]:I rddataout_1[16]:I rddataout_1[15]:I rddataout_1[14]:I rddataout_1[13]:I rddataout_1[12]:I rddataout_1[11]:I rddataout_1[10]:I rddataout_1[9]:I rddataout_1[8]:I rddataout_1[7]:I rddataout_1[6]:I rddataout_1[5]:I rddataout_1[4]:I rddataout_1[3]:I rddataout_1[2]:I rddataout_1[1]:I
*.PININFO rddataout_1[0]:I selbnk0nn:I selbnk1nn:I vcc:I vss:I
Xgioslice[67] clkrdsync clkwr2h2l idin[67] idin1l[67] lyal0bl[67] lyal0blnn[67]
+ lyal1bl lyal1blnn lyasel odout[67] rddataout_0[67] rddataout_1[67] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[66] clkrdsync clkwr2h2l idin[66] idin1l[66] lyal0bl[66] lyal0blnn[66]
+ lyal1bl lyal1blnn lyasel odout[66] rddataout_0[66] rddataout_1[66] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[65] clkrdsync clkwr2h2l idin[65] idin1l[65] lyal0bl[65] lyal0blnn[65]
+ lyal1bl lyal1blnn lyasel odout[65] rddataout_0[65] rddataout_1[65] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[64] clkrdsync clkwr2h2l idin[64] idin1l[64] lyal0bl[64] lyal0blnn[64]
+ lyal1bl lyal1blnn lyasel odout[64] rddataout_0[64] rddataout_1[64] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[63] clkrdsync clkwr2h2l idin[63] idin1l[63] lyal0bl[63] lyal0blnn[63]
+ lyal1bl lyal1blnn lyasel odout[63] rddataout_0[63] rddataout_1[63] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[62] clkrdsync clkwr2h2l idin[62] idin1l[62] lyal0bl[62] lyal0blnn[62]
+ lyal1bl lyal1blnn lyasel odout[62] rddataout_0[62] rddataout_1[62] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[61] clkrdsync clkwr2h2l idin[61] idin1l[61] lyal0bl[61] lyal0blnn[61]
+ lyal1bl lyal1blnn lyasel odout[61] rddataout_0[61] rddataout_1[61] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[60] clkrdsync clkwr2h2l idin[60] idin1l[60] lyal0bl[60] lyal0blnn[60]
+ lyal1bl lyal1blnn lyasel odout[60] rddataout_0[60] rddataout_1[60] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[59] clkrdsync clkwr2h2l idin[59] idin1l[59] lyal0bl[59] lyal0blnn[59]
+ lyal1bl lyal1blnn lyasel odout[59] rddataout_0[59] rddataout_1[59] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[58] clkrdsync clkwr2h2l idin[58] idin1l[58] lyal0bl[58] lyal0blnn[58]
+ lyal1bl lyal1blnn lyasel odout[58] rddataout_0[58] rddataout_1[58] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[57] clkrdsync clkwr2h2l idin[57] idin1l[57] lyal0bl[57] lyal0blnn[57]
+ lyal1bl lyal1blnn lyasel odout[57] rddataout_0[57] rddataout_1[57] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[56] clkrdsync clkwr2h2l idin[56] idin1l[56] lyal0bl[56] lyal0blnn[56]
+ lyal1bl lyal1blnn lyasel odout[56] rddataout_0[56] rddataout_1[56] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[55] clkrdsync clkwr2h2l idin[55] idin1l[55] lyal0bl[55] lyal0blnn[55]
+ lyal1bl lyal1blnn lyasel odout[55] rddataout_0[55] rddataout_1[55] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[54] clkrdsync clkwr2h2l idin[54] idin1l[54] lyal0bl[54] lyal0blnn[54]
+ lyal1bl lyal1blnn lyasel odout[54] rddataout_0[54] rddataout_1[54] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[53] clkrdsync clkwr2h2l idin[53] idin1l[53] lyal0bl[53] lyal0blnn[53]
+ lyal1bl lyal1blnn lyasel odout[53] rddataout_0[53] rddataout_1[53] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[52] clkrdsync clkwr2h2l idin[52] idin1l[52] lyal0bl[52] lyal0blnn[52]
+ lyal1bl lyal1blnn lyasel odout[52] rddataout_0[52] rddataout_1[52] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[51] clkrdsync clkwr2h2l idin[51] idin1l[51] lyal0bl[51] lyal0blnn[51]
+ lyal1bl lyal1blnn lyasel odout[51] rddataout_0[51] rddataout_1[51] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[50] clkrdsync clkwr2h2l idin[50] idin1l[50] lyal0bl[50] lyal0blnn[50]
+ lyal1bl lyal1blnn lyasel odout[50] rddataout_0[50] rddataout_1[50] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[49] clkrdsync clkwr2h2l idin[49] idin1l[49] lyal0bl[49] lyal0blnn[49]
+ lyal1bl lyal1blnn lyasel odout[49] rddataout_0[49] rddataout_1[49] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[48] clkrdsync clkwr2h2l idin[48] idin1l[48] lyal0bl[48] lyal0blnn[48]
+ lyal1bl lyal1blnn lyasel odout[48] rddataout_0[48] rddataout_1[48] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[47] clkrdsync clkwr2h2l idin[47] idin1l[47] lyal0bl[47] lyal0blnn[47]
+ lyal1bl lyal1blnn lyasel odout[47] rddataout_0[47] rddataout_1[47] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[46] clkrdsync clkwr2h2l idin[46] idin1l[46] lyal0bl[46] lyal0blnn[46]
+ lyal1bl lyal1blnn lyasel odout[46] rddataout_0[46] rddataout_1[46] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[45] clkrdsync clkwr2h2l idin[45] idin1l[45] lyal0bl[45] lyal0blnn[45]
+ lyal1bl lyal1blnn lyasel odout[45] rddataout_0[45] rddataout_1[45] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[44] clkrdsync clkwr2h2l idin[44] idin1l[44] lyal0bl[44] lyal0blnn[44]
+ lyal1bl lyal1blnn lyasel odout[44] rddataout_0[44] rddataout_1[44] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[43] clkrdsync clkwr2h2l idin[43] idin1l[43] lyal0bl[43] lyal0blnn[43]
+ lyal1bl lyal1blnn lyasel odout[43] rddataout_0[43] rddataout_1[43] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[42] clkrdsync clkwr2h2l idin[42] idin1l[42] lyal0bl[42] lyal0blnn[42]
+ lyal1bl lyal1blnn lyasel odout[42] rddataout_0[42] rddataout_1[42] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[41] clkrdsync clkwr2h2l idin[41] idin1l[41] lyal0bl[41] lyal0blnn[41]
+ lyal1bl lyal1blnn lyasel odout[41] rddataout_0[41] rddataout_1[41] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[40] clkrdsync clkwr2h2l idin[40] idin1l[40] lyal0bl[40] lyal0blnn[40]
+ lyal1bl lyal1blnn lyasel odout[40] rddataout_0[40] rddataout_1[40] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[39] clkrdsync clkwr2h2l idin[39] idin1l[39] lyal0bl[39] lyal0blnn[39]
+ lyal1bl lyal1blnn lyasel odout[39] rddataout_0[39] rddataout_1[39] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[38] clkrdsync clkwr2h2l idin[38] idin1l[38] lyal0bl[38] lyal0blnn[38]
+ lyal1bl lyal1blnn lyasel odout[38] rddataout_0[38] rddataout_1[38] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[37] clkrdsync clkwr2h2l idin[37] idin1l[37] lyal0bl[37] lyal0blnn[37]
+ lyal1bl lyal1blnn lyasel odout[37] rddataout_0[37] rddataout_1[37] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[36] clkrdsync clkwr2h2l idin[36] idin1l[36] lyal0bl[36] lyal0blnn[36]
+ lyal1bl lyal1blnn lyasel odout[36] rddataout_0[36] rddataout_1[36] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[35] clkrdsync clkwr2h2l idin[35] idin1l[35] lyal0bl[35] lyal0blnn[35]
+ lyal1bl lyal1blnn lyasel odout[35] rddataout_0[35] rddataout_1[35] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[34] clkrdsync clkwr2h2l idin[34] idin1l[34] lyal0bl[34] lyal0blnn[34]
+ lyal1bl lyal1blnn lyasel odout[34] rddataout_0[34] rddataout_1[34] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[33] clkrdsync clkwr2h2l idin[33] idin1l[33] lyal0bl[33] lyal0blnn[33]
+ lyal1bl lyal1blnn lyasel odout[33] rddataout_0[33] rddataout_1[33] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[32] clkrdsync clkwr2h2l idin[32] idin1l[32] lyal0bl[32] lyal0blnn[32]
+ lyal1bl lyal1blnn lyasel odout[32] rddataout_0[32] rddataout_1[32] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[31] clkrdsync clkwr2h2l idin[31] idin1l[31] lyal0bl[31] lyal0blnn[31]
+ lyal1bl lyal1blnn lyasel odout[31] rddataout_0[31] rddataout_1[31] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[30] clkrdsync clkwr2h2l idin[30] idin1l[30] lyal0bl[30] lyal0blnn[30]
+ lyal1bl lyal1blnn lyasel odout[30] rddataout_0[30] rddataout_1[30] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[29] clkrdsync clkwr2h2l idin[29] idin1l[29] lyal0bl[29] lyal0blnn[29]
+ lyal1bl lyal1blnn lyasel odout[29] rddataout_0[29] rddataout_1[29] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[28] clkrdsync clkwr2h2l idin[28] idin1l[28] lyal0bl[28] lyal0blnn[28]
+ lyal1bl lyal1blnn lyasel odout[28] rddataout_0[28] rddataout_1[28] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[27] clkrdsync clkwr2h2l idin[27] idin1l[27] lyal0bl[27] lyal0blnn[27]
+ lyal1bl lyal1blnn lyasel odout[27] rddataout_0[27] rddataout_1[27] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[26] clkrdsync clkwr2h2l idin[26] idin1l[26] lyal0bl[26] lyal0blnn[26]
+ lyal1bl lyal1blnn lyasel odout[26] rddataout_0[26] rddataout_1[26] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[25] clkrdsync clkwr2h2l idin[25] idin1l[25] lyal0bl[25] lyal0blnn[25]
+ lyal1bl lyal1blnn lyasel odout[25] rddataout_0[25] rddataout_1[25] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[24] clkrdsync clkwr2h2l idin[24] idin1l[24] lyal0bl[24] lyal0blnn[24]
+ lyal1bl lyal1blnn lyasel odout[24] rddataout_0[24] rddataout_1[24] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[23] clkrdsync clkwr2h2l idin[23] idin1l[23] lyal0bl[23] lyal0blnn[23]
+ lyal1bl lyal1blnn lyasel odout[23] rddataout_0[23] rddataout_1[23] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[22] clkrdsync clkwr2h2l idin[22] idin1l[22] lyal0bl[22] lyal0blnn[22]
+ lyal1bl lyal1blnn lyasel odout[22] rddataout_0[22] rddataout_1[22] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[21] clkrdsync clkwr2h2l idin[21] idin1l[21] lyal0bl[21] lyal0blnn[21]
+ lyal1bl lyal1blnn lyasel odout[21] rddataout_0[21] rddataout_1[21] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[20] clkrdsync clkwr2h2l idin[20] idin1l[20] lyal0bl[20] lyal0blnn[20]
+ lyal1bl lyal1blnn lyasel odout[20] rddataout_0[20] rddataout_1[20] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[19] clkrdsync clkwr2h2l idin[19] idin1l[19] lyal0bl[19] lyal0blnn[19]
+ lyal1bl lyal1blnn lyasel odout[19] rddataout_0[19] rddataout_1[19] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[18] clkrdsync clkwr2h2l idin[18] idin1l[18] lyal0bl[18] lyal0blnn[18]
+ lyal1bl lyal1blnn lyasel odout[18] rddataout_0[18] rddataout_1[18] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[17] clkrdsync clkwr2h2l idin[17] idin1l[17] lyal0bl[17] lyal0blnn[17]
+ lyal1bl lyal1blnn lyasel odout[17] rddataout_0[17] rddataout_1[17] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[16] clkrdsync clkwr2h2l idin[16] idin1l[16] lyal0bl[16] lyal0blnn[16]
+ lyal1bl lyal1blnn lyasel odout[16] rddataout_0[16] rddataout_1[16] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[15] clkrdsync clkwr2h2l idin[15] idin1l[15] lyal0bl[15] lyal0blnn[15]
+ lyal1bl lyal1blnn lyasel odout[15] rddataout_0[15] rddataout_1[15] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[14] clkrdsync clkwr2h2l idin[14] idin1l[14] lyal0bl[14] lyal0blnn[14]
+ lyal1bl lyal1blnn lyasel odout[14] rddataout_0[14] rddataout_1[14] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[13] clkrdsync clkwr2h2l idin[13] idin1l[13] lyal0bl[13] lyal0blnn[13]
+ lyal1bl lyal1blnn lyasel odout[13] rddataout_0[13] rddataout_1[13] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[12] clkrdsync clkwr2h2l idin[12] idin1l[12] lyal0bl[12] lyal0blnn[12]
+ lyal1bl lyal1blnn lyasel odout[12] rddataout_0[12] rddataout_1[12] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[11] clkrdsync clkwr2h2l idin[11] idin1l[11] lyal0bl[11] lyal0blnn[11]
+ lyal1bl lyal1blnn lyasel odout[11] rddataout_0[11] rddataout_1[11] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[10] clkrdsync clkwr2h2l idin[10] idin1l[10] lyal0bl[10] lyal0blnn[10]
+ lyal1bl lyal1blnn lyasel odout[10] rddataout_0[10] rddataout_1[10] selbnk0nn selbnk1nn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[9] clkrdsync clkwr2h2l idin[9] idin1l[9] lyal0bl[9] lyal0blnn[9] lyal1bl
+ lyal1blnn lyasel odout[9] rddataout_0[9] rddataout_1[9] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[8] clkrdsync clkwr2h2l idin[8] idin1l[8] lyal0bl[8] lyal0blnn[8] lyal1bl
+ lyal1blnn lyasel odout[8] rddataout_0[8] rddataout_1[8] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[7] clkrdsync clkwr2h2l idin[7] idin1l[7] lyal0bl[7] lyal0blnn[7] lyal1bl
+ lyal1blnn lyasel odout[7] rddataout_0[7] rddataout_1[7] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[6] clkrdsync clkwr2h2l idin[6] idin1l[6] lyal0bl[6] lyal0blnn[6] lyal1bl
+ lyal1blnn lyasel odout[6] rddataout_0[6] rddataout_1[6] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[5] clkrdsync clkwr2h2l idin[5] idin1l[5] lyal0bl[5] lyal0blnn[5] lyal1bl
+ lyal1blnn lyasel odout[5] rddataout_0[5] rddataout_1[5] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[4] clkrdsync clkwr2h2l idin[4] idin1l[4] lyal0bl[4] lyal0blnn[4] lyal1bl
+ lyal1blnn lyasel odout[4] rddataout_0[4] rddataout_1[4] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[3] clkrdsync clkwr2h2l idin[3] idin1l[3] lyal0bl[3] lyal0blnn[3] lyal1bl
+ lyal1blnn lyasel odout[3] rddataout_0[3] rddataout_1[3] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[2] clkrdsync clkwr2h2l idin[2] idin1l[2] lyal0bl[2] lyal0blnn[2] lyal1bl
+ lyal1blnn lyasel odout[2] rddataout_0[2] rddataout_1[2] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[1] clkrdsync clkwr2h2l idin[1] idin1l[1] lyal0bl[1] lyal0blnn[1] lyal1bl
+ lyal1blnn lyasel odout[1] rddataout_0[1] rddataout_1[1] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
Xgioslice[0] clkrdsync clkwr2h2l idin[0] idin1l[0] lyal0bl[0] lyal0blnn[0] lyal1bl
+ lyal1blnn lyasel odout[0] rddataout_0[0] rddataout_1[0] selbnk0nn selbnk1nn vcc
+ vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_gioslice
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccbit2x4
* View Name:    schematic
************************************************************************
.SUBCKT issahccbit2x4 bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc
+ sramvss wl[1] wl[0]
*.PININFO bl[3]:B bl[2]:B bl[1]:B bl[0]:B bl_b[3]:B bl_b[2]:B bl_b[1]:B bl_b[0]:B sramvcc:I sramvss:I wl[1]:I wl[0]:I
Xiary2x1[3] bl[3] bl_b[3] sramvcc sramvss wl[1] wl[0] x78hcc5bit2x1
Xiary2x1[2] bl[2] bl_b[2] sramvcc sramvss wl[1] wl[0] x78hcc5bit2x1
Xiary2x1[1] bl[1] bl_b[1] sramvcc sramvss wl[1] wl[0] x78hcc5bit2x1
Xiary2x1[0] bl[0] bl_b[0] sramvcc sramvss wl[1] wl[0] x78hcc5bit2x1
.ENDS

*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahcc5edg1x4_ru
* View Name:    schematic
************************************************************************
.SUBCKT issahcc5edg1x4_ru bl[3] bl[2] bl[1] bl[0] sramvcc[3] sramvcc[2] sramvcc[1]
+ sramvcc[0] sramvss
*.PININFO bl[3]:B bl[2]:B bl[1]:B bl[0]:B sramvcc[3]:I sramvcc[2]:I sramvcc[1]:I sramvcc[0]:I sramvss:I
Xibitedge[0] bl[1] bl[0] sramvcc[1] sramvcc[0] sramvss x78hcc5edg1x2
Xibitedge[1] bl[2] bl[3] sramvcc[2] sramvcc[3] sramvss x78hcc5edg1x2
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccarytrkdrv8x2
* View Name:    schematic
************************************************************************
.SUBCKT issahccarytrkdrv8x2 bl_noconn[0] dwl noconn[0] noconn[1] sramvcc sramvcc_noconn
+ sramvss trkbl wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0]
*.PININFO bl_noconn[0]:I dwl:I noconn[0]:I noconn[1]:I sramvcc:I sramvcc_noconn:I sramvss:I trkbl:B wl[7]:I wl[6]:I wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I
Xiary2x2[1] bl_noconn[0] trkbl noconn[0] noconn[1] dwl sramvcc sramvcc_noconn sramvss
+ wl[3] wl[2] x78hcc5drvtrk2x2
Xiary2x2[2] bl_noconn[0] trkbl noconn[0] noconn[1] dwl sramvcc sramvcc_noconn sramvss
+ wl[5] wl[4] x78hcc5drvtrk2x2
Xiary2x2[3] bl_noconn[0] trkbl noconn[0] noconn[1] dwl sramvcc sramvcc_noconn sramvss
+ wl[7] wl[6] x78hcc5drvtrk2x2
Xiary2x2[0] bl_noconn[0] trkbl noconn[0] noconn[1] dwl sramvcc sramvcc_noconn sramvss
+ wl[1] wl[0] x78hcc5drvtrk2x2
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccarytrkncn8x2
* View Name:    schematic
************************************************************************
.SUBCKT issahccarytrkncn8x2 bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn
+ sramvss trkbl wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0]
*.PININFO bl_noconn[0]:I noconn[0]:I noconn[1]:I sramvcc:I sramvcc_noconn:I sramvss:I trkbl:B wl[7]:I wl[6]:I wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I
Xiary2x2[1] bl_noconn[0] trkbl noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss
+ wl[3] wl[2] x78hcc5ncntrk2x2
Xiary2x2[2] bl_noconn[0] trkbl noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss
+ wl[5] wl[4] x78hcc5ncntrk2x2
Xiary2x2[3] bl_noconn[0] trkbl noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss
+ wl[7] wl[6] x78hcc5ncntrk2x2
Xiary2x2[0] bl_noconn[0] trkbl noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss
+ wl[1] wl[0] x78hcc5ncntrk2x2
.ENDS

************************************************************************
* auCdl Netlist:
* VMAC_VER:	 24.06.17_rc
* Library Name:  ip78p6customsram
* Top Cell Name: issahccarytrkncn256x2
* View Name:     schematic
************************************************************************
*.RESI = 1e-06
*.RESVAL
*.CAPVAL
*.DIOPERI
*.DIOAREA
*.EQUATION
*.EXPAND_ON_M_FACTOR
************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccarytrkrdncn2x2
* View Name:    schematic
************************************************************************
.SUBCKT issahccarytrkrdncn2x2 bl_bnoconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn
+ sramvss trkbl wl[1] wl[0]
*.PININFO bl_bnoconn[0]:I noconn[0]:I noconn[1]:I sramvcc:I sramvcc_noconn:I sramvss:I trkbl:I wl[1]:I wl[0]:I
Xibitred bl_bnoconn[0] trkbl noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss
+ wl[1] wl[0] x78hcc5ncntrk2x2
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccarytrkred2x2
* View Name:    schematic
************************************************************************
.SUBCKT issahccarytrkred2x2 bl_bnoconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn
+ sramvss trkbl wl[1] wl[0]
*.PININFO bl_bnoconn[0]:I noconn[0]:I noconn[1]:I sramvcc:I sramvcc_noconn:I sramvss:I trkbl:I wl[1]:I wl[0]:I
Xibitred bl_bnoconn[0] trkbl noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss
+ wl[1] wl[0] x78hcc5ldtrk2x2
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccarytrkld8x2
* View Name:    schematic
************************************************************************
.SUBCKT issahccarytrkld8x2 bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn
+ sramvss trkbl wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0]
*.PININFO bl_noconn[0]:I noconn[0]:I noconn[1]:I sramvcc:I sramvcc_noconn:I sramvss:I trkbl:B wl[7]:I wl[6]:I wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I
Xiary2x2[1] bl_noconn[0] trkbl noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss
+ wl[3] wl[2] x78hcc5ldtrk2x2
Xiary2x2[2] bl_noconn[0] trkbl noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss
+ wl[5] wl[4] x78hcc5ldtrk2x2
Xiary2x2[3] bl_noconn[0] trkbl noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss
+ wl[7] wl[6] x78hcc5ldtrk2x2
Xiary2x2[0] bl_noconn[0] trkbl noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss
+ wl[1] wl[0] x78hcc5ldtrk2x2
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_timer activered#[1] activered#[0] bankgrant1h
+ clkbank clkwrsynckicknn finekick[3] finekick[2] finekick[1] finekick[0] fz_asynckick#
+ fz_asyncrd# fz_asyncwr# fz_finekick#[3] fz_finekick#[2] fz_finekick#[1] fz_finekick#[0]
+ fz_rassel#[2] fz_rassel#[1] fz_rassel#[0] fz_rdwlcut# fz_rdwlpw#[3] fz_rdwlpw#[2]
+ fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw#[1] fz_saepw#[0] fz_synckick fz_syncrd fz_syncwr
+ fz_trbwassel#[2] fz_trbwassel#[1] fz_trbwassel#[0] fz_trkwllvl#[2] fz_trkwllvl#[1]
+ fz_trkwllvl#[0] fz_wassel#[2] fz_wassel#[1] fz_wassel#[0] fz_wrwlcut# fz_wrwlpw#[1]
+ fz_wrwlpw#[0] grant1l grant2h hi#[7] hi#[6] hi#[5] hi#[4] hi#[3] hi#[2] hi#[1]
+ hi#[0] ia_hi#[2] ia_hi#[1] ia_hi#[0] ia_mid#[2] ia_mid#[1] ia_mid#[0] ia_wle#[1]
+ ia_wle#[0] iwren1h iwren1l2l iwren2h3h lyaennn lyanowl# lyasel mid#[7] mid#[6]
+ mid#[5] mid#[4] mid#[3] mid#[2] mid#[1] mid#[0] nbl_kicknn_dn nbl_kicknn_up nblkick
+ pcnn0_dn pcnn0_up pcnn1_dn pcnn1_up rdwl rdwlclkmx rdwlpw[3] rdwlpw[2] rdwlpw[1]
+ rdwlpw[0] rdysel0_dn[3] rdysel0_dn[2] rdysel0_dn[1] rdysel0_dn[0] rdysel0_up[3]
+ rdysel0_up[2] rdysel0_up[1] rdysel0_up[0] rdysel1_dn[3] rdysel1_dn[2] rdysel1_dn[1]
+ rdysel1_dn[0] rdysel1_up[3] rdysel1_up[2] rdysel1_up[1] rdysel1_up[0] saenn_dn
+ saenn_up sapchnn_dn sapchnn_up sideen[0] slpen0 slpen1 trkwllvlnn[2] trkwllvlnn[1]
+ trkwllvlnn[0] turbomode# vcc vss waenn_dn[2] waenn_dn[1] waenn_dn[0] waenn_up[2]
+ waenn_up[1] waenn_up[0] wayselbnk[3] wayselbnk[2] wayselbnk[1] wayselbnk[0] wle0[3]
+ wle0[2] wle0[1] wle0[0] wle1[3] wle1[2] wle1[1] wle1[0] wlered0[1] wlered0[0]
+ wlered1[1] wlered1[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wrclk_dn wrclk_up wrcolsel0_dn[3]
+ wrcolsel0_dn[2] wrcolsel0_dn[1] wrcolsel0_dn[0] wrcolsel0_up[3] wrcolsel0_up[2]
+ wrcolsel0_up[1] wrcolsel0_up[0] wrcolsel1_dn[3] wrcolsel1_dn[2] wrcolsel1_dn[1]
+ wrcolsel1_dn[0] wrcolsel1_up[3] wrcolsel1_up[2] wrcolsel1_up[1] wrcolsel1_up[0]
+ wrdataen_dn wrdataen_up wrwl wrwlclkmx wrwlpw[1] wrwlpw[0]
*.PININFO activered#[1]:I activered#[0]:I bankgrant1h:I clkbank:I clkwrsynckicknn:O finekick[3]:O finekick[2]:O finekick[1]:O finekick[0]:O fz_asynckick#:I fz_asyncrd#:I fz_asyncwr#:I fz_finekick#[3]:I fz_finekick#[2]:I fz_finekick#[1]:I fz_finekick#[0]:I fz_rassel#[2]:I fz_rassel#[1]:I fz_rassel#[0]:I fz_rdwlcut#:I
*.PININFO fz_rdwlpw#[3]:I fz_rdwlpw#[2]:I fz_rdwlpw#[1]:I fz_rdwlpw#[0]:I fz_saepw#[1]:I fz_saepw#[0]:I fz_synckick:O fz_syncrd:O fz_syncwr:O fz_trbwassel#[2]:I fz_trbwassel#[1]:I fz_trbwassel#[0]:I fz_trkwllvl#[2]:I fz_trkwllvl#[1]:I fz_trkwllvl#[0]:I fz_wassel#[2]:I fz_wassel#[1]:I fz_wassel#[0]:I fz_wrwlcut#:I fz_wrwlpw#[1]:I
*.PININFO fz_wrwlpw#[0]:I grant1l:I grant2h:I hi#[7]:O hi#[6]:O hi#[5]:O hi#[4]:O hi#[3]:O hi#[2]:O hi#[1]:O hi#[0]:O ia_hi#[2]:I ia_hi#[1]:I ia_hi#[0]:I ia_mid#[2]:I ia_mid#[1]:I ia_mid#[0]:I ia_wle#[1]:I ia_wle#[0]:I iwren1h:I
*.PININFO iwren1l2l:I iwren2h3h:I lyaennn:O lyanowl#:I lyasel:I mid#[7]:O mid#[6]:O mid#[5]:O mid#[4]:O mid#[3]:O mid#[2]:O mid#[1]:O mid#[0]:O nbl_kicknn_dn:O nbl_kicknn_up:O nblkick:I pcnn0_dn:O pcnn0_up:O pcnn1_dn:O pcnn1_up:O
*.PININFO rdwl:O rdwlclkmx:I rdwlpw[3]:O rdwlpw[2]:O rdwlpw[1]:O rdwlpw[0]:O rdysel0_dn[3]:O rdysel0_dn[2]:O rdysel0_dn[1]:O rdysel0_dn[0]:O rdysel0_up[3]:O rdysel0_up[2]:O rdysel0_up[1]:O rdysel0_up[0]:O rdysel1_dn[3]:O rdysel1_dn[2]:O rdysel1_dn[1]:O rdysel1_dn[0]:O rdysel1_up[3]:O rdysel1_up[2]:O
*.PININFO rdysel1_up[1]:O rdysel1_up[0]:O saenn_dn:O saenn_up:O sapchnn_dn:O sapchnn_up:O sideen[0]:I slpen0:O slpen1:O trkwllvlnn[2]:O trkwllvlnn[1]:O trkwllvlnn[0]:O turbomode#:I vcc:I vss:I waenn_dn[2]:O waenn_dn[1]:O waenn_dn[0]:O waenn_up[2]:O waenn_up[1]:O
*.PININFO waenn_up[0]:O wayselbnk[3]:I wayselbnk[2]:I wayselbnk[1]:I wayselbnk[0]:I wle0[3]:O wle0[2]:O wle0[1]:O wle0[0]:O wle1[3]:O wle1[2]:O wle1[1]:O wle1[0]:O wlered0[1]:O wlered0[0]:O wlered1[1]:O wlered1[0]:O wllvlnn[2]:O wllvlnn[1]:O wllvlnn[0]:O
*.PININFO wrclk_dn:O wrclk_up:O wrcolsel0_dn[3]:O wrcolsel0_dn[2]:O wrcolsel0_dn[1]:O wrcolsel0_dn[0]:O wrcolsel0_up[3]:O wrcolsel0_up[2]:O wrcolsel0_up[1]:O wrcolsel0_up[0]:O wrcolsel1_dn[3]:O wrcolsel1_dn[2]:O wrcolsel1_dn[1]:O wrcolsel1_dn[0]:O wrcolsel1_up[3]:O wrcolsel1_up[2]:O wrcolsel1_up[1]:O wrcolsel1_up[0]:O wrdataen_dn:O wrdataen_up:O
*.PININFO wrwl:O wrwlclkmx:I wrwlpw[1]:O wrwlpw[0]:O
Xip78d6hcf2sr4096x135m4i2k4w8r2lya_timer_dcap_container vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_timer_dcap_container
Xi1 vcc vss i0mzdcf33ub1n04x5
Xirep0[1] yseladdrdec[1] yseladdrdec_rep0[1] vcc vss i0mbfm201ac1n03x5
Xirep0[0] yseladdrdec[0] yseladdrdec_rep0[0] vcc vss i0mbfm201ac1n03x5
Xirep0[2] yseladdrdec[2] yseladdrdec_rep0[2] vcc vss i0mbfm201ac1n03x5
Xirep0[3] yseladdrdec[3] yseladdrdec_rep0[3] vcc vss i0mbfm201ac1n03x5
Xsidetimer[0] activered1l[1] activered1l[0] blpch clkrd clksaemx clkwl clkwrysel#
+ fz_syncrd pcnn0_dn pcnn0_up rdysel0_dn[3] rdysel0_dn[2] rdysel0_dn[1] rdysel0_dn[0]
+ rdysel0_up[3] rdysel0_up[2] rdysel0_up[1] rdysel0_up[0] redactive1l# pickside1l[0]
+ slpen0 slpen1l# vcc vss wle0[3] wle0[2] wle0[1] wle0[0] wleaddrdec[3] wleaddrdec[2]
+ wleaddrdec[1] wleaddrdec[0] wlered0[1] wlered0[0] wrcolsel0_dn[3] wrcolsel0_dn[2]
+ wrcolsel0_dn[1] wrcolsel0_dn[0] wrcolsel0_up[3] wrcolsel0_up[2] wrcolsel0_up[1]
+ wrcolsel0_up[0] yseladdrdec_rep[3] yseladdrdec_rep[2] yseladdrdec_rep[1] yseladdrdec_rep[0] ip78d6hcf2sr4096x135m4i2k4w8r2lya_sidetimer
Xcentimer activered#[1] activered#[0] activered1l[1] activered1l[0] bankgrant1h
+ blpch clkbank clkrd rdwl clksaemx clkwl wrwl clkwrsynckicknn clkwrysel# finekick[3]
+ finekick[2] finekick[1] finekick[0] fz_asynckick# fz_asyncrd# fz_asyncwr# fz_finekick#[3]
+ fz_finekick#[2] fz_finekick#[1] fz_finekick#[0] fz_rassel#[2] fz_rassel#[1] fz_rassel#[0]
+ fz_rdwlcut# fz_rdwlpw#[3] fz_rdwlpw#[2] fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw#[1]
+ fz_saepw#[0] fz_synckick fz_syncrd fz_syncwr fz_trbwassel#[2] fz_trbwassel#[1]
+ fz_trbwassel#[0] fz_trkwllvl#[2] fz_trkwllvl#[1] fz_trkwllvl#[0] fz_wassel#[2]
+ fz_wassel#[1] fz_wassel#[0] fz_wrwlcut# fz_wrwlpw#[1] fz_wrwlpw#[0] grant1l grant2h
+ hi#[7] hi#[6] hi#[5] hi#[4] hi#[3] hi#[2] hi#[1] hi#[0] ia_hi#[2] ia_hi#[1] ia_hi#[0]
+ ia_mid#[2] ia_mid#[1] ia_mid#[0] ia_wle#[1] ia_wle#[0] iwren1h iwren1l2l iwren2h3h
+ lyaennn lyanowl# lyasel mid#[7] mid#[6] mid#[5] mid#[4] mid#[3] mid#[2] mid#[1]
+ mid#[0] nbl_kicknn_dn nbl_kicknn_up nblkick pickside1l[1] pickside1l[0] rdwlclkmx
+ rdwlpw[3] rdwlpw[2] rdwlpw[1] rdwlpw[0] redactive1l# saenn_dn saenn_up sapchnn_dn
+ sapchnn_up sideen[0] slpen1l# trkwllvlnn[2] trkwllvlnn[1] trkwllvlnn[0] turbomode#
+ vcc vss waenn_dn[2] waenn_dn[1] waenn_dn[0] waenn_up[2] waenn_up[1] waenn_up[0]
+ wayselbnk[3] wayselbnk[2] wayselbnk[1] wayselbnk[0] wleaddrdec[3] wleaddrdec[2]
+ wleaddrdec[1] wleaddrdec[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wrclk_dn wrclk_up
+ wrdataen_dn wrdataen_up wrwlclkmx wrwlpw[1] wrwlpw[0] yseladdrdec[3] yseladdrdec[2]
+ yseladdrdec[1] yseladdrdec[0] ip78d6hcf2sr4096x135m4i2k4w8r2lya_centimer
Xirep[1] yseladdrdec_rep0[1] yseladdrdec_rep[1] vcc vss i0mbfm201ab1n04x5
Xirep[0] yseladdrdec_rep0[0] yseladdrdec_rep[0] vcc vss i0mbfm201ab1n04x5
Xirep[3] yseladdrdec_rep0[3] yseladdrdec_rep[3] vcc vss i0mbfm201ab1n04x5
Xirep[2] yseladdrdec_rep0[2] yseladdrdec_rep[2] vcc vss i0mbfm201ab1n04x5
Xsidetimer[1] activered1l[1] activered1l[0] blpch clkrd clksaemx clkwl clkwrysel#
+ fz_syncrd pcnn1_dn pcnn1_up rdysel1_dn[3] rdysel1_dn[2] rdysel1_dn[1] rdysel1_dn[0]
+ rdysel1_up[3] rdysel1_up[2] rdysel1_up[1] rdysel1_up[0] redactive1l# pickside1l[1]
+ slpen1 slpen1l# vcc vss wle1[3] wle1[2] wle1[1] wle1[0] wleaddrdec[3] wleaddrdec[2]
+ wleaddrdec[1] wleaddrdec[0] wlered1[1] wlered1[0] wrcolsel1_dn[3] wrcolsel1_dn[2]
+ wrcolsel1_dn[1] wrcolsel1_dn[0] wrcolsel1_up[3] wrcolsel1_up[2] wrcolsel1_up[1]
+ wrcolsel1_up[0] yseladdrdec_rep[3] yseladdrdec_rep[2] yseladdrdec_rep[1] yseladdrdec_rep[0] ip78d6hcf2sr4096x135m4i2k4w8r2lya_sidetimer
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_gio activered#[1] activered#[0] bankgrant1h[1]
+ bankgrant1h[0] bankgrant1l[1] bankgrant1l[0] bankgrant2h[1] bankgrant2h[0] clk
+ clkbank fz_asynckick fz_asynckick# fz_asyncrd fz_asyncrd# fz_asyncwr fz_asyncwr#
+ fz_clkgate fz_finekick[3] fz_finekick[2] fz_finekick[1] fz_finekick[0] fz_finekick#[3]
+ fz_finekick#[2] fz_finekick#[1] fz_finekick#[0] fz_rassel[2] fz_rassel[1] fz_rassel[0]
+ fz_rassel#[2] fz_rassel#[1] fz_rassel#[0] fz_rdwlcut fz_rdwlcut# fz_rdwlpw[3]
+ fz_rdwlpw[2] fz_rdwlpw[1] fz_rdwlpw[0] fz_rdwlpw#[3] fz_rdwlpw#[2] fz_rdwlpw#[1]
+ fz_rdwlpw#[0] fz_saepw[1] fz_saepw[0] fz_saepw#[1] fz_saepw#[0] fz_trbwassel[2]
+ fz_trbwassel[1] fz_trbwassel[0] fz_trbwassel#[2] fz_trbwassel#[1] fz_trbwassel#[0]
+ fz_trkwllvl[2] fz_trkwllvl[1] fz_trkwllvl[0] fz_trkwllvl#[2] fz_trkwllvl#[1] fz_trkwllvl#[0]
+ fz_wassel[2] fz_wassel[1] fz_wassel[0] fz_wassel#[2] fz_wassel#[1] fz_wassel#[0]
+ fz_wrwlcut fz_wrwlcut# fz_wrwlpw[1] fz_wrwlpw[0] fz_wrwlpw#[1] fz_wrwlpw#[0] grant
+ ia[8] ia[7] ia[6] ia[5] ia[4] ia[3] ia[2] ia[1] ia[0] ia_hi#[2] ia_hi#[1] ia_hi#[0]
+ ia_mid#[2] ia_mid#[1] ia_mid#[0] ia_wle#[1] ia_wle#[0] idin[134] idin[133] idin[132]
+ idin[131] idin[130] idin[129] idin[128] idin[127] idin[126] idin[125] idin[124]
+ idin[123] idin[122] idin[121] idin[120] idin[119] idin[118] idin[117] idin[116]
+ idin[115] idin[114] idin[113] idin[112] idin[111] idin[110] idin[109] idin[108]
+ idin[107] idin[106] idin[105] idin[104] idin[103] idin[102] idin[101] idin[100]
+ idin[99] idin[98] idin[97] idin[96] idin[95] idin[94] idin[93] idin[92] idin[91]
+ idin[90] idin[89] idin[88] idin[87] idin[86] idin[85] idin[84] idin[83] idin[82]
+ idin[81] idin[80] idin[79] idin[78] idin[77] idin[76] idin[75] idin[74] idin[73]
+ idin[72] idin[71] idin[70] idin[69] idin[68] idin[67] idin[66] idin[65] idin[64]
+ idin[63] idin[62] idin[61] idin[60] idin[59] idin[58] idin[57] idin[56] idin[55]
+ idin[54] idin[53] idin[52] idin[51] idin[50] idin[49] idin[48] idin[47] idin[46]
+ idin[45] idin[44] idin[43] idin[42] idin[41] idin[40] idin[39] idin[38] idin[37]
+ idin[36] idin[35] idin[34] idin[33] idin[32] idin[31] idin[30] idin[29] idin[28]
+ idin[27] idin[26] idin[25] idin[24] idin[23] idin[22] idin[21] idin[20] idin[19]
+ idin[18] idin[17] idin[16] idin[15] idin[14] idin[13] idin[12] idin[11] idin[10]
+ idin[9] idin[8] idin[7] idin[6] idin[5] idin[4] idin[3] idin[2] idin[1] idin[0]
+ idin1l[134] idin1l[133] idin1l[132] idin1l[131] idin1l[130] idin1l[129] idin1l[128]
+ idin1l[127] idin1l[126] idin1l[125] idin1l[124] idin1l[123] idin1l[122] idin1l[121]
+ idin1l[120] idin1l[119] idin1l[118] idin1l[117] idin1l[116] idin1l[115] idin1l[114]
+ idin1l[113] idin1l[112] idin1l[111] idin1l[110] idin1l[109] idin1l[108] idin1l[107]
+ idin1l[106] idin1l[105] idin1l[104] idin1l[103] idin1l[102] idin1l[101] idin1l[100]
+ idin1l[99] idin1l[98] idin1l[97] idin1l[96] idin1l[95] idin1l[94] idin1l[93] idin1l[92]
+ idin1l[91] idin1l[90] idin1l[89] idin1l[88] idin1l[87] idin1l[86] idin1l[85] idin1l[84]
+ idin1l[83] idin1l[82] idin1l[81] idin1l[80] idin1l[79] idin1l[78] idin1l[77] idin1l[76]
+ idin1l[75] idin1l[74] idin1l[73] idin1l[72] idin1l[71] idin1l[70] idin1l[69] idin1l[68]
+ idin1l[67] idin1l[66] idin1l[65] idin1l[64] idin1l[63] idin1l[62] idin1l[61] idin1l[60]
+ idin1l[59] idin1l[58] idin1l[57] idin1l[56] idin1l[55] idin1l[54] idin1l[53] idin1l[52]
+ idin1l[51] idin1l[50] idin1l[49] idin1l[48] idin1l[47] idin1l[46] idin1l[45] idin1l[44]
+ idin1l[43] idin1l[42] idin1l[41] idin1l[40] idin1l[39] idin1l[38] idin1l[37] idin1l[36]
+ idin1l[35] idin1l[34] idin1l[33] idin1l[32] idin1l[31] idin1l[30] idin1l[29] idin1l[28]
+ idin1l[27] idin1l[26] idin1l[25] idin1l[24] idin1l[23] idin1l[22] idin1l[21] idin1l[20]
+ idin1l[19] idin1l[18] idin1l[17] idin1l[16] idin1l[15] idin1l[14] idin1l[13] idin1l[12]
+ idin1l[11] idin1l[10] idin1l[9] idin1l[8] idin1l[7] idin1l[6] idin1l[5] idin1l[4]
+ idin1l[3] idin1l[2] idin1l[1] idin1l[0] irowredun[1] irowredun[0] iway[7] iway[6]
+ iway[5] iway[4] iway[3] iway[2] iway[1] iway[0] iwen iwren1h iwren1l2l iwren2h3h
+ lyabnk lyaclkstop lyaen lyal0bl[134] lyal0bl[133] lyal0bl[132] lyal0bl[131] lyal0bl[130]
+ lyal0bl[129] lyal0bl[128] lyal0bl[127] lyal0bl[126] lyal0bl[125] lyal0bl[124]
+ lyal0bl[123] lyal0bl[122] lyal0bl[121] lyal0bl[120] lyal0bl[119] lyal0bl[118]
+ lyal0bl[117] lyal0bl[116] lyal0bl[115] lyal0bl[114] lyal0bl[113] lyal0bl[112]
+ lyal0bl[111] lyal0bl[110] lyal0bl[109] lyal0bl[108] lyal0bl[107] lyal0bl[106]
+ lyal0bl[105] lyal0bl[104] lyal0bl[103] lyal0bl[102] lyal0bl[101] lyal0bl[100]
+ lyal0bl[99] lyal0bl[98] lyal0bl[97] lyal0bl[96] lyal0bl[95] lyal0bl[94] lyal0bl[93]
+ lyal0bl[92] lyal0bl[91] lyal0bl[90] lyal0bl[89] lyal0bl[88] lyal0bl[87] lyal0bl[86]
+ lyal0bl[85] lyal0bl[84] lyal0bl[83] lyal0bl[82] lyal0bl[81] lyal0bl[80] lyal0bl[79]
+ lyal0bl[78] lyal0bl[77] lyal0bl[76] lyal0bl[75] lyal0bl[74] lyal0bl[73] lyal0bl[72]
+ lyal0bl[71] lyal0bl[70] lyal0bl[69] lyal0bl[68] lyal0bl[67] lyal0bl[66] lyal0bl[65]
+ lyal0bl[64] lyal0bl[63] lyal0bl[62] lyal0bl[61] lyal0bl[60] lyal0bl[59] lyal0bl[58]
+ lyal0bl[57] lyal0bl[56] lyal0bl[55] lyal0bl[54] lyal0bl[53] lyal0bl[52] lyal0bl[51]
+ lyal0bl[50] lyal0bl[49] lyal0bl[48] lyal0bl[47] lyal0bl[46] lyal0bl[45] lyal0bl[44]
+ lyal0bl[43] lyal0bl[42] lyal0bl[41] lyal0bl[40] lyal0bl[39] lyal0bl[38] lyal0bl[37]
+ lyal0bl[36] lyal0bl[35] lyal0bl[34] lyal0bl[33] lyal0bl[32] lyal0bl[31] lyal0bl[30]
+ lyal0bl[29] lyal0bl[28] lyal0bl[27] lyal0bl[26] lyal0bl[25] lyal0bl[24] lyal0bl[23]
+ lyal0bl[22] lyal0bl[21] lyal0bl[20] lyal0bl[19] lyal0bl[18] lyal0bl[17] lyal0bl[16]
+ lyal0bl[15] lyal0bl[14] lyal0bl[13] lyal0bl[12] lyal0bl[11] lyal0bl[10] lyal0bl[9]
+ lyal0bl[8] lyal0bl[7] lyal0bl[6] lyal0bl[5] lyal0bl[4] lyal0bl[3] lyal0bl[2] lyal0bl[1]
+ lyal0bl[0] lyal0blnn[134] lyal0blnn[133] lyal0blnn[132] lyal0blnn[131] lyal0blnn[130]
+ lyal0blnn[129] lyal0blnn[128] lyal0blnn[127] lyal0blnn[126] lyal0blnn[125] lyal0blnn[124]
+ lyal0blnn[123] lyal0blnn[122] lyal0blnn[121] lyal0blnn[120] lyal0blnn[119] lyal0blnn[118]
+ lyal0blnn[117] lyal0blnn[116] lyal0blnn[115] lyal0blnn[114] lyal0blnn[113] lyal0blnn[112]
+ lyal0blnn[111] lyal0blnn[110] lyal0blnn[109] lyal0blnn[108] lyal0blnn[107] lyal0blnn[106]
+ lyal0blnn[105] lyal0blnn[104] lyal0blnn[103] lyal0blnn[102] lyal0blnn[101] lyal0blnn[100]
+ lyal0blnn[99] lyal0blnn[98] lyal0blnn[97] lyal0blnn[96] lyal0blnn[95] lyal0blnn[94]
+ lyal0blnn[93] lyal0blnn[92] lyal0blnn[91] lyal0blnn[90] lyal0blnn[89] lyal0blnn[88]
+ lyal0blnn[87] lyal0blnn[86] lyal0blnn[85] lyal0blnn[84] lyal0blnn[83] lyal0blnn[82]
+ lyal0blnn[81] lyal0blnn[80] lyal0blnn[79] lyal0blnn[78] lyal0blnn[77] lyal0blnn[76]
+ lyal0blnn[75] lyal0blnn[74] lyal0blnn[73] lyal0blnn[72] lyal0blnn[71] lyal0blnn[70]
+ lyal0blnn[69] lyal0blnn[68] lyal0blnn[67] lyal0blnn[66] lyal0blnn[65] lyal0blnn[64]
+ lyal0blnn[63] lyal0blnn[62] lyal0blnn[61] lyal0blnn[60] lyal0blnn[59] lyal0blnn[58]
+ lyal0blnn[57] lyal0blnn[56] lyal0blnn[55] lyal0blnn[54] lyal0blnn[53] lyal0blnn[52]
+ lyal0blnn[51] lyal0blnn[50] lyal0blnn[49] lyal0blnn[48] lyal0blnn[47] lyal0blnn[46]
+ lyal0blnn[45] lyal0blnn[44] lyal0blnn[43] lyal0blnn[42] lyal0blnn[41] lyal0blnn[40]
+ lyal0blnn[39] lyal0blnn[38] lyal0blnn[37] lyal0blnn[36] lyal0blnn[35] lyal0blnn[34]
+ lyal0blnn[33] lyal0blnn[32] lyal0blnn[31] lyal0blnn[30] lyal0blnn[29] lyal0blnn[28]
+ lyal0blnn[27] lyal0blnn[26] lyal0blnn[25] lyal0blnn[24] lyal0blnn[23] lyal0blnn[22]
+ lyal0blnn[21] lyal0blnn[20] lyal0blnn[19] lyal0blnn[18] lyal0blnn[17] lyal0blnn[16]
+ lyal0blnn[15] lyal0blnn[14] lyal0blnn[13] lyal0blnn[12] lyal0blnn[11] lyal0blnn[10]
+ lyal0blnn[9] lyal0blnn[8] lyal0blnn[7] lyal0blnn[6] lyal0blnn[5] lyal0blnn[4]
+ lyal0blnn[3] lyal0blnn[2] lyal0blnn[1] lyal0blnn[0] lyal2bl lyal2blnn lyanowl
+ lyanowl# lyaseltmr odout[134] odout[133] odout[132] odout[131] odout[130] odout[129]
+ odout[128] odout[127] odout[126] odout[125] odout[124] odout[123] odout[122] odout[121]
+ odout[120] odout[119] odout[118] odout[117] odout[116] odout[115] odout[114] odout[113]
+ odout[112] odout[111] odout[110] odout[109] odout[108] odout[107] odout[106] odout[105]
+ odout[104] odout[103] odout[102] odout[101] odout[100] odout[99] odout[98] odout[97]
+ odout[96] odout[95] odout[94] odout[93] odout[92] odout[91] odout[90] odout[89]
+ odout[88] odout[87] odout[86] odout[85] odout[84] odout[83] odout[82] odout[81]
+ odout[80] odout[79] odout[78] odout[77] odout[76] odout[75] odout[74] odout[73]
+ odout[72] odout[71] odout[70] odout[69] odout[68] odout[67] odout[66] odout[65]
+ odout[64] odout[63] odout[62] odout[61] odout[60] odout[59] odout[58] odout[57]
+ odout[56] odout[55] odout[54] odout[53] odout[52] odout[51] odout[50] odout[49]
+ odout[48] odout[47] odout[46] odout[45] odout[44] odout[43] odout[42] odout[41]
+ odout[40] odout[39] odout[38] odout[37] odout[36] odout[35] odout[34] odout[33]
+ odout[32] odout[31] odout[30] odout[29] odout[28] odout[27] odout[26] odout[25]
+ odout[24] odout[23] odout[22] odout[21] odout[20] odout[19] odout[18] odout[17]
+ odout[16] odout[15] odout[14] odout[13] odout[12] odout[11] odout[10] odout[9]
+ odout[8] odout[7] odout[6] odout[5] odout[4] odout[3] odout[2] odout[1] odout[0]
+ rddataout_0[134] rddataout_0[133] rddataout_0[132] rddataout_0[131] rddataout_0[130]
+ rddataout_0[129] rddataout_0[128] rddataout_0[127] rddataout_0[126] rddataout_0[125]
+ rddataout_0[124] rddataout_0[123] rddataout_0[122] rddataout_0[121] rddataout_0[120]
+ rddataout_0[119] rddataout_0[118] rddataout_0[117] rddataout_0[116] rddataout_0[115]
+ rddataout_0[114] rddataout_0[113] rddataout_0[112] rddataout_0[111] rddataout_0[110]
+ rddataout_0[109] rddataout_0[108] rddataout_0[107] rddataout_0[106] rddataout_0[105]
+ rddataout_0[104] rddataout_0[103] rddataout_0[102] rddataout_0[101] rddataout_0[100]
+ rddataout_0[99] rddataout_0[98] rddataout_0[97] rddataout_0[96] rddataout_0[95]
+ rddataout_0[94] rddataout_0[93] rddataout_0[92] rddataout_0[91] rddataout_0[90]
+ rddataout_0[89] rddataout_0[88] rddataout_0[87] rddataout_0[86] rddataout_0[85]
+ rddataout_0[84] rddataout_0[83] rddataout_0[82] rddataout_0[81] rddataout_0[80]
+ rddataout_0[79] rddataout_0[78] rddataout_0[77] rddataout_0[76] rddataout_0[75]
+ rddataout_0[74] rddataout_0[73] rddataout_0[72] rddataout_0[71] rddataout_0[70]
+ rddataout_0[69] rddataout_0[68] rddataout_0[67] rddataout_0[66] rddataout_0[65]
+ rddataout_0[64] rddataout_0[63] rddataout_0[62] rddataout_0[61] rddataout_0[60]
+ rddataout_0[59] rddataout_0[58] rddataout_0[57] rddataout_0[56] rddataout_0[55]
+ rddataout_0[54] rddataout_0[53] rddataout_0[52] rddataout_0[51] rddataout_0[50]
+ rddataout_0[49] rddataout_0[48] rddataout_0[47] rddataout_0[46] rddataout_0[45]
+ rddataout_0[44] rddataout_0[43] rddataout_0[42] rddataout_0[41] rddataout_0[40]
+ rddataout_0[39] rddataout_0[38] rddataout_0[37] rddataout_0[36] rddataout_0[35]
+ rddataout_0[34] rddataout_0[33] rddataout_0[32] rddataout_0[31] rddataout_0[30]
+ rddataout_0[29] rddataout_0[28] rddataout_0[27] rddataout_0[26] rddataout_0[25]
+ rddataout_0[24] rddataout_0[23] rddataout_0[22] rddataout_0[21] rddataout_0[20]
+ rddataout_0[19] rddataout_0[18] rddataout_0[17] rddataout_0[16] rddataout_0[15]
+ rddataout_0[14] rddataout_0[13] rddataout_0[12] rddataout_0[11] rddataout_0[10]
+ rddataout_0[9] rddataout_0[8] rddataout_0[7] rddataout_0[6] rddataout_0[5] rddataout_0[4]
+ rddataout_0[3] rddataout_0[2] rddataout_0[1] rddataout_0[0] rddataout_1[134] rddataout_1[133]
+ rddataout_1[132] rddataout_1[131] rddataout_1[130] rddataout_1[129] rddataout_1[128]
+ rddataout_1[127] rddataout_1[126] rddataout_1[125] rddataout_1[124] rddataout_1[123]
+ rddataout_1[122] rddataout_1[121] rddataout_1[120] rddataout_1[119] rddataout_1[118]
+ rddataout_1[117] rddataout_1[116] rddataout_1[115] rddataout_1[114] rddataout_1[113]
+ rddataout_1[112] rddataout_1[111] rddataout_1[110] rddataout_1[109] rddataout_1[108]
+ rddataout_1[107] rddataout_1[106] rddataout_1[105] rddataout_1[104] rddataout_1[103]
+ rddataout_1[102] rddataout_1[101] rddataout_1[100] rddataout_1[99] rddataout_1[98]
+ rddataout_1[97] rddataout_1[96] rddataout_1[95] rddataout_1[94] rddataout_1[93]
+ rddataout_1[92] rddataout_1[91] rddataout_1[90] rddataout_1[89] rddataout_1[88]
+ rddataout_1[87] rddataout_1[86] rddataout_1[85] rddataout_1[84] rddataout_1[83]
+ rddataout_1[82] rddataout_1[81] rddataout_1[80] rddataout_1[79] rddataout_1[78]
+ rddataout_1[77] rddataout_1[76] rddataout_1[75] rddataout_1[74] rddataout_1[73]
+ rddataout_1[72] rddataout_1[71] rddataout_1[70] rddataout_1[69] rddataout_1[68]
+ rddataout_1[67] rddataout_1[66] rddataout_1[65] rddataout_1[64] rddataout_1[63]
+ rddataout_1[62] rddataout_1[61] rddataout_1[60] rddataout_1[59] rddataout_1[58]
+ rddataout_1[57] rddataout_1[56] rddataout_1[55] rddataout_1[54] rddataout_1[53]
+ rddataout_1[52] rddataout_1[51] rddataout_1[50] rddataout_1[49] rddataout_1[48]
+ rddataout_1[47] rddataout_1[46] rddataout_1[45] rddataout_1[44] rddataout_1[43]
+ rddataout_1[42] rddataout_1[41] rddataout_1[40] rddataout_1[39] rddataout_1[38]
+ rddataout_1[37] rddataout_1[36] rddataout_1[35] rddataout_1[34] rddataout_1[33]
+ rddataout_1[32] rddataout_1[31] rddataout_1[30] rddataout_1[29] rddataout_1[28]
+ rddataout_1[27] rddataout_1[26] rddataout_1[25] rddataout_1[24] rddataout_1[23]
+ rddataout_1[22] rddataout_1[21] rddataout_1[20] rddataout_1[19] rddataout_1[18]
+ rddataout_1[17] rddataout_1[16] rddataout_1[15] rddataout_1[14] rddataout_1[13]
+ rddataout_1[12] rddataout_1[11] rddataout_1[10] rddataout_1[9] rddataout_1[8]
+ rddataout_1[7] rddataout_1[6] rddataout_1[5] rddataout_1[4] rddataout_1[3] rddataout_1[2]
+ rddataout_1[1] rddataout_1[0] sideen[0] turbomode turbomode# vcc vss wayselbnk[3]
+ wayselbnk[2] wayselbnk[1] wayselbnk[0]
*.PININFO activered#[1]:O activered#[0]:O bankgrant1h[1]:O bankgrant1h[0]:O bankgrant1l[1]:O bankgrant1l[0]:O bankgrant2h[1]:O bankgrant2h[0]:O clk:I clkbank:O fz_asynckick:I fz_asynckick#:O fz_asyncrd:I fz_asyncrd#:O fz_asyncwr:I fz_asyncwr#:O fz_clkgate:I fz_finekick[3]:I fz_finekick[2]:I fz_finekick[1]:I
*.PININFO fz_finekick[0]:I fz_finekick#[3]:O fz_finekick#[2]:O fz_finekick#[1]:O fz_finekick#[0]:O fz_rassel[2]:I fz_rassel[1]:I fz_rassel[0]:I fz_rassel#[2]:O fz_rassel#[1]:O fz_rassel#[0]:O fz_rdwlcut:I fz_rdwlcut#:O fz_rdwlpw[3]:I fz_rdwlpw[2]:I fz_rdwlpw[1]:I fz_rdwlpw[0]:I fz_rdwlpw#[3]:O fz_rdwlpw#[2]:O fz_rdwlpw#[1]:O
*.PININFO fz_rdwlpw#[0]:O fz_saepw[1]:I fz_saepw[0]:I fz_saepw#[1]:O fz_saepw#[0]:O fz_trbwassel[2]:I fz_trbwassel[1]:I fz_trbwassel[0]:I fz_trbwassel#[2]:O fz_trbwassel#[1]:O fz_trbwassel#[0]:O fz_trkwllvl[2]:I fz_trkwllvl[1]:I fz_trkwllvl[0]:I fz_trkwllvl#[2]:O fz_trkwllvl#[1]:O fz_trkwllvl#[0]:O fz_wassel[2]:I fz_wassel[1]:I fz_wassel[0]:I
*.PININFO fz_wassel#[2]:O fz_wassel#[1]:O fz_wassel#[0]:O fz_wrwlcut:I fz_wrwlcut#:O fz_wrwlpw[1]:I fz_wrwlpw[0]:I fz_wrwlpw#[1]:O fz_wrwlpw#[0]:O grant:I ia[8]:I ia[7]:I ia[6]:I ia[5]:I ia[4]:I ia[3]:I ia[2]:I ia[1]:I ia[0]:I ia_hi#[2]:O
*.PININFO ia_hi#[1]:O ia_hi#[0]:O ia_mid#[2]:O ia_mid#[1]:O ia_mid#[0]:O ia_wle#[1]:O ia_wle#[0]:O idin[134]:I idin[133]:I idin[132]:I idin[131]:I idin[130]:I idin[129]:I idin[128]:I idin[127]:I idin[126]:I idin[125]:I idin[124]:I idin[123]:I idin[122]:I
*.PININFO idin[121]:I idin[120]:I idin[119]:I idin[118]:I idin[117]:I idin[116]:I idin[115]:I idin[114]:I idin[113]:I idin[112]:I idin[111]:I idin[110]:I idin[109]:I idin[108]:I idin[107]:I idin[106]:I idin[105]:I idin[104]:I idin[103]:I idin[102]:I
*.PININFO idin[101]:I idin[100]:I idin[99]:I idin[98]:I idin[97]:I idin[96]:I idin[95]:I idin[94]:I idin[93]:I idin[92]:I idin[91]:I idin[90]:I idin[89]:I idin[88]:I idin[87]:I idin[86]:I idin[85]:I idin[84]:I idin[83]:I idin[82]:I
*.PININFO idin[81]:I idin[80]:I idin[79]:I idin[78]:I idin[77]:I idin[76]:I idin[75]:I idin[74]:I idin[73]:I idin[72]:I idin[71]:I idin[70]:I idin[69]:I idin[68]:I idin[67]:I idin[66]:I idin[65]:I idin[64]:I idin[63]:I idin[62]:I
*.PININFO idin[61]:I idin[60]:I idin[59]:I idin[58]:I idin[57]:I idin[56]:I idin[55]:I idin[54]:I idin[53]:I idin[52]:I idin[51]:I idin[50]:I idin[49]:I idin[48]:I idin[47]:I idin[46]:I idin[45]:I idin[44]:I idin[43]:I idin[42]:I
*.PININFO idin[41]:I idin[40]:I idin[39]:I idin[38]:I idin[37]:I idin[36]:I idin[35]:I idin[34]:I idin[33]:I idin[32]:I idin[31]:I idin[30]:I idin[29]:I idin[28]:I idin[27]:I idin[26]:I idin[25]:I idin[24]:I idin[23]:I idin[22]:I
*.PININFO idin[21]:I idin[20]:I idin[19]:I idin[18]:I idin[17]:I idin[16]:I idin[15]:I idin[14]:I idin[13]:I idin[12]:I idin[11]:I idin[10]:I idin[9]:I idin[8]:I idin[7]:I idin[6]:I idin[5]:I idin[4]:I idin[3]:I idin[2]:I
*.PININFO idin[1]:I idin[0]:I idin1l[134]:O idin1l[133]:O idin1l[132]:O idin1l[131]:O idin1l[130]:O idin1l[129]:O idin1l[128]:O idin1l[127]:O idin1l[126]:O idin1l[125]:O idin1l[124]:O idin1l[123]:O idin1l[122]:O idin1l[121]:O idin1l[120]:O idin1l[119]:O idin1l[118]:O idin1l[117]:O
*.PININFO idin1l[116]:O idin1l[115]:O idin1l[114]:O idin1l[113]:O idin1l[112]:O idin1l[111]:O idin1l[110]:O idin1l[109]:O idin1l[108]:O idin1l[107]:O idin1l[106]:O idin1l[105]:O idin1l[104]:O idin1l[103]:O idin1l[102]:O idin1l[101]:O idin1l[100]:O idin1l[99]:O idin1l[98]:O idin1l[97]:O
*.PININFO idin1l[96]:O idin1l[95]:O idin1l[94]:O idin1l[93]:O idin1l[92]:O idin1l[91]:O idin1l[90]:O idin1l[89]:O idin1l[88]:O idin1l[87]:O idin1l[86]:O idin1l[85]:O idin1l[84]:O idin1l[83]:O idin1l[82]:O idin1l[81]:O idin1l[80]:O idin1l[79]:O idin1l[78]:O idin1l[77]:O
*.PININFO idin1l[76]:O idin1l[75]:O idin1l[74]:O idin1l[73]:O idin1l[72]:O idin1l[71]:O idin1l[70]:O idin1l[69]:O idin1l[68]:O idin1l[67]:O idin1l[66]:O idin1l[65]:O idin1l[64]:O idin1l[63]:O idin1l[62]:O idin1l[61]:O idin1l[60]:O idin1l[59]:O idin1l[58]:O idin1l[57]:O
*.PININFO idin1l[56]:O idin1l[55]:O idin1l[54]:O idin1l[53]:O idin1l[52]:O idin1l[51]:O idin1l[50]:O idin1l[49]:O idin1l[48]:O idin1l[47]:O idin1l[46]:O idin1l[45]:O idin1l[44]:O idin1l[43]:O idin1l[42]:O idin1l[41]:O idin1l[40]:O idin1l[39]:O idin1l[38]:O idin1l[37]:O
*.PININFO idin1l[36]:O idin1l[35]:O idin1l[34]:O idin1l[33]:O idin1l[32]:O idin1l[31]:O idin1l[30]:O idin1l[29]:O idin1l[28]:O idin1l[27]:O idin1l[26]:O idin1l[25]:O idin1l[24]:O idin1l[23]:O idin1l[22]:O idin1l[21]:O idin1l[20]:O idin1l[19]:O idin1l[18]:O idin1l[17]:O
*.PININFO idin1l[16]:O idin1l[15]:O idin1l[14]:O idin1l[13]:O idin1l[12]:O idin1l[11]:O idin1l[10]:O idin1l[9]:O idin1l[8]:O idin1l[7]:O idin1l[6]:O idin1l[5]:O idin1l[4]:O idin1l[3]:O idin1l[2]:O idin1l[1]:O idin1l[0]:O irowredun[1]:I irowredun[0]:I iway[7]:I
*.PININFO iway[6]:I iway[5]:I iway[4]:I iway[3]:I iway[2]:I iway[1]:I iway[0]:I iwen:I iwren1h:O iwren1l2l:O iwren2h3h:O lyabnk:I lyaclkstop:I lyaen:I lyal0bl[134]:O lyal0bl[133]:O lyal0bl[132]:O lyal0bl[131]:O lyal0bl[130]:O lyal0bl[129]:O
*.PININFO lyal0bl[128]:O lyal0bl[127]:O lyal0bl[126]:O lyal0bl[125]:O lyal0bl[124]:O lyal0bl[123]:O lyal0bl[122]:O lyal0bl[121]:O lyal0bl[120]:O lyal0bl[119]:O lyal0bl[118]:O lyal0bl[117]:O lyal0bl[116]:O lyal0bl[115]:O lyal0bl[114]:O lyal0bl[113]:O lyal0bl[112]:O lyal0bl[111]:O lyal0bl[110]:O lyal0bl[109]:O
*.PININFO lyal0bl[108]:O lyal0bl[107]:O lyal0bl[106]:O lyal0bl[105]:O lyal0bl[104]:O lyal0bl[103]:O lyal0bl[102]:O lyal0bl[101]:O lyal0bl[100]:O lyal0bl[99]:O lyal0bl[98]:O lyal0bl[97]:O lyal0bl[96]:O lyal0bl[95]:O lyal0bl[94]:O lyal0bl[93]:O lyal0bl[92]:O lyal0bl[91]:O lyal0bl[90]:O lyal0bl[89]:O
*.PININFO lyal0bl[88]:O lyal0bl[87]:O lyal0bl[86]:O lyal0bl[85]:O lyal0bl[84]:O lyal0bl[83]:O lyal0bl[82]:O lyal0bl[81]:O lyal0bl[80]:O lyal0bl[79]:O lyal0bl[78]:O lyal0bl[77]:O lyal0bl[76]:O lyal0bl[75]:O lyal0bl[74]:O lyal0bl[73]:O lyal0bl[72]:O lyal0bl[71]:O lyal0bl[70]:O lyal0bl[69]:O
*.PININFO lyal0bl[68]:O lyal0bl[67]:O lyal0bl[66]:O lyal0bl[65]:O lyal0bl[64]:O lyal0bl[63]:O lyal0bl[62]:O lyal0bl[61]:O lyal0bl[60]:O lyal0bl[59]:O lyal0bl[58]:O lyal0bl[57]:O lyal0bl[56]:O lyal0bl[55]:O lyal0bl[54]:O lyal0bl[53]:O lyal0bl[52]:O lyal0bl[51]:O lyal0bl[50]:O lyal0bl[49]:O
*.PININFO lyal0bl[48]:O lyal0bl[47]:O lyal0bl[46]:O lyal0bl[45]:O lyal0bl[44]:O lyal0bl[43]:O lyal0bl[42]:O lyal0bl[41]:O lyal0bl[40]:O lyal0bl[39]:O lyal0bl[38]:O lyal0bl[37]:O lyal0bl[36]:O lyal0bl[35]:O lyal0bl[34]:O lyal0bl[33]:O lyal0bl[32]:O lyal0bl[31]:O lyal0bl[30]:O lyal0bl[29]:O
*.PININFO lyal0bl[28]:O lyal0bl[27]:O lyal0bl[26]:O lyal0bl[25]:O lyal0bl[24]:O lyal0bl[23]:O lyal0bl[22]:O lyal0bl[21]:O lyal0bl[20]:O lyal0bl[19]:O lyal0bl[18]:O lyal0bl[17]:O lyal0bl[16]:O lyal0bl[15]:O lyal0bl[14]:O lyal0bl[13]:O lyal0bl[12]:O lyal0bl[11]:O lyal0bl[10]:O lyal0bl[9]:O
*.PININFO lyal0bl[8]:O lyal0bl[7]:O lyal0bl[6]:O lyal0bl[5]:O lyal0bl[4]:O lyal0bl[3]:O lyal0bl[2]:O lyal0bl[1]:O lyal0bl[0]:O lyal0blnn[134]:O lyal0blnn[133]:O lyal0blnn[132]:O lyal0blnn[131]:O lyal0blnn[130]:O lyal0blnn[129]:O lyal0blnn[128]:O lyal0blnn[127]:O lyal0blnn[126]:O lyal0blnn[125]:O lyal0blnn[124]:O
*.PININFO lyal0blnn[123]:O lyal0blnn[122]:O lyal0blnn[121]:O lyal0blnn[120]:O lyal0blnn[119]:O lyal0blnn[118]:O lyal0blnn[117]:O lyal0blnn[116]:O lyal0blnn[115]:O lyal0blnn[114]:O lyal0blnn[113]:O lyal0blnn[112]:O lyal0blnn[111]:O lyal0blnn[110]:O lyal0blnn[109]:O lyal0blnn[108]:O lyal0blnn[107]:O lyal0blnn[106]:O lyal0blnn[105]:O lyal0blnn[104]:O
*.PININFO lyal0blnn[103]:O lyal0blnn[102]:O lyal0blnn[101]:O lyal0blnn[100]:O lyal0blnn[99]:O lyal0blnn[98]:O lyal0blnn[97]:O lyal0blnn[96]:O lyal0blnn[95]:O lyal0blnn[94]:O lyal0blnn[93]:O lyal0blnn[92]:O lyal0blnn[91]:O lyal0blnn[90]:O lyal0blnn[89]:O lyal0blnn[88]:O lyal0blnn[87]:O lyal0blnn[86]:O lyal0blnn[85]:O lyal0blnn[84]:O
*.PININFO lyal0blnn[83]:O lyal0blnn[82]:O lyal0blnn[81]:O lyal0blnn[80]:O lyal0blnn[79]:O lyal0blnn[78]:O lyal0blnn[77]:O lyal0blnn[76]:O lyal0blnn[75]:O lyal0blnn[74]:O lyal0blnn[73]:O lyal0blnn[72]:O lyal0blnn[71]:O lyal0blnn[70]:O lyal0blnn[69]:O lyal0blnn[68]:O lyal0blnn[67]:O lyal0blnn[66]:O lyal0blnn[65]:O lyal0blnn[64]:O
*.PININFO lyal0blnn[63]:O lyal0blnn[62]:O lyal0blnn[61]:O lyal0blnn[60]:O lyal0blnn[59]:O lyal0blnn[58]:O lyal0blnn[57]:O lyal0blnn[56]:O lyal0blnn[55]:O lyal0blnn[54]:O lyal0blnn[53]:O lyal0blnn[52]:O lyal0blnn[51]:O lyal0blnn[50]:O lyal0blnn[49]:O lyal0blnn[48]:O lyal0blnn[47]:O lyal0blnn[46]:O lyal0blnn[45]:O lyal0blnn[44]:O
*.PININFO lyal0blnn[43]:O lyal0blnn[42]:O lyal0blnn[41]:O lyal0blnn[40]:O lyal0blnn[39]:O lyal0blnn[38]:O lyal0blnn[37]:O lyal0blnn[36]:O lyal0blnn[35]:O lyal0blnn[34]:O lyal0blnn[33]:O lyal0blnn[32]:O lyal0blnn[31]:O lyal0blnn[30]:O lyal0blnn[29]:O lyal0blnn[28]:O lyal0blnn[27]:O lyal0blnn[26]:O lyal0blnn[25]:O lyal0blnn[24]:O
*.PININFO lyal0blnn[23]:O lyal0blnn[22]:O lyal0blnn[21]:O lyal0blnn[20]:O lyal0blnn[19]:O lyal0blnn[18]:O lyal0blnn[17]:O lyal0blnn[16]:O lyal0blnn[15]:O lyal0blnn[14]:O lyal0blnn[13]:O lyal0blnn[12]:O lyal0blnn[11]:O lyal0blnn[10]:O lyal0blnn[9]:O lyal0blnn[8]:O lyal0blnn[7]:O lyal0blnn[6]:O lyal0blnn[5]:O lyal0blnn[4]:O
*.PININFO lyal0blnn[3]:O lyal0blnn[2]:O lyal0blnn[1]:O lyal0blnn[0]:O lyal2bl:I lyal2blnn:I lyanowl:I lyanowl#:O lyaseltmr:O odout[134]:O odout[133]:O odout[132]:O odout[131]:O odout[130]:O odout[129]:O odout[128]:O odout[127]:O odout[126]:O odout[125]:O odout[124]:O
*.PININFO odout[123]:O odout[122]:O odout[121]:O odout[120]:O odout[119]:O odout[118]:O odout[117]:O odout[116]:O odout[115]:O odout[114]:O odout[113]:O odout[112]:O odout[111]:O odout[110]:O odout[109]:O odout[108]:O odout[107]:O odout[106]:O odout[105]:O odout[104]:O
*.PININFO odout[103]:O odout[102]:O odout[101]:O odout[100]:O odout[99]:O odout[98]:O odout[97]:O odout[96]:O odout[95]:O odout[94]:O odout[93]:O odout[92]:O odout[91]:O odout[90]:O odout[89]:O odout[88]:O odout[87]:O odout[86]:O odout[85]:O odout[84]:O
*.PININFO odout[83]:O odout[82]:O odout[81]:O odout[80]:O odout[79]:O odout[78]:O odout[77]:O odout[76]:O odout[75]:O odout[74]:O odout[73]:O odout[72]:O odout[71]:O odout[70]:O odout[69]:O odout[68]:O odout[67]:O odout[66]:O odout[65]:O odout[64]:O
*.PININFO odout[63]:O odout[62]:O odout[61]:O odout[60]:O odout[59]:O odout[58]:O odout[57]:O odout[56]:O odout[55]:O odout[54]:O odout[53]:O odout[52]:O odout[51]:O odout[50]:O odout[49]:O odout[48]:O odout[47]:O odout[46]:O odout[45]:O odout[44]:O
*.PININFO odout[43]:O odout[42]:O odout[41]:O odout[40]:O odout[39]:O odout[38]:O odout[37]:O odout[36]:O odout[35]:O odout[34]:O odout[33]:O odout[32]:O odout[31]:O odout[30]:O odout[29]:O odout[28]:O odout[27]:O odout[26]:O odout[25]:O odout[24]:O
*.PININFO odout[23]:O odout[22]:O odout[21]:O odout[20]:O odout[19]:O odout[18]:O odout[17]:O odout[16]:O odout[15]:O odout[14]:O odout[13]:O odout[12]:O odout[11]:O odout[10]:O odout[9]:O odout[8]:O odout[7]:O odout[6]:O odout[5]:O odout[4]:O
*.PININFO odout[3]:O odout[2]:O odout[1]:O odout[0]:O rddataout_0[134]:I rddataout_0[133]:I rddataout_0[132]:I rddataout_0[131]:I rddataout_0[130]:I rddataout_0[129]:I rddataout_0[128]:I rddataout_0[127]:I rddataout_0[126]:I rddataout_0[125]:I rddataout_0[124]:I rddataout_0[123]:I rddataout_0[122]:I rddataout_0[121]:I rddataout_0[120]:I rddataout_0[119]:I
*.PININFO rddataout_0[118]:I rddataout_0[117]:I rddataout_0[116]:I rddataout_0[115]:I rddataout_0[114]:I rddataout_0[113]:I rddataout_0[112]:I rddataout_0[111]:I rddataout_0[110]:I rddataout_0[109]:I rddataout_0[108]:I rddataout_0[107]:I rddataout_0[106]:I rddataout_0[105]:I rddataout_0[104]:I rddataout_0[103]:I rddataout_0[102]:I rddataout_0[101]:I rddataout_0[100]:I rddataout_0[99]:I
*.PININFO rddataout_0[98]:I rddataout_0[97]:I rddataout_0[96]:I rddataout_0[95]:I rddataout_0[94]:I rddataout_0[93]:I rddataout_0[92]:I rddataout_0[91]:I rddataout_0[90]:I rddataout_0[89]:I rddataout_0[88]:I rddataout_0[87]:I rddataout_0[86]:I rddataout_0[85]:I rddataout_0[84]:I rddataout_0[83]:I rddataout_0[82]:I rddataout_0[81]:I rddataout_0[80]:I rddataout_0[79]:I
*.PININFO rddataout_0[78]:I rddataout_0[77]:I rddataout_0[76]:I rddataout_0[75]:I rddataout_0[74]:I rddataout_0[73]:I rddataout_0[72]:I rddataout_0[71]:I rddataout_0[70]:I rddataout_0[69]:I rddataout_0[68]:I rddataout_0[67]:I rddataout_0[66]:I rddataout_0[65]:I rddataout_0[64]:I rddataout_0[63]:I rddataout_0[62]:I rddataout_0[61]:I rddataout_0[60]:I rddataout_0[59]:I
*.PININFO rddataout_0[58]:I rddataout_0[57]:I rddataout_0[56]:I rddataout_0[55]:I rddataout_0[54]:I rddataout_0[53]:I rddataout_0[52]:I rddataout_0[51]:I rddataout_0[50]:I rddataout_0[49]:I rddataout_0[48]:I rddataout_0[47]:I rddataout_0[46]:I rddataout_0[45]:I rddataout_0[44]:I rddataout_0[43]:I rddataout_0[42]:I rddataout_0[41]:I rddataout_0[40]:I rddataout_0[39]:I
*.PININFO rddataout_0[38]:I rddataout_0[37]:I rddataout_0[36]:I rddataout_0[35]:I rddataout_0[34]:I rddataout_0[33]:I rddataout_0[32]:I rddataout_0[31]:I rddataout_0[30]:I rddataout_0[29]:I rddataout_0[28]:I rddataout_0[27]:I rddataout_0[26]:I rddataout_0[25]:I rddataout_0[24]:I rddataout_0[23]:I rddataout_0[22]:I rddataout_0[21]:I rddataout_0[20]:I rddataout_0[19]:I
*.PININFO rddataout_0[18]:I rddataout_0[17]:I rddataout_0[16]:I rddataout_0[15]:I rddataout_0[14]:I rddataout_0[13]:I rddataout_0[12]:I rddataout_0[11]:I rddataout_0[10]:I rddataout_0[9]:I rddataout_0[8]:I rddataout_0[7]:I rddataout_0[6]:I rddataout_0[5]:I rddataout_0[4]:I rddataout_0[3]:I rddataout_0[2]:I rddataout_0[1]:I rddataout_0[0]:I rddataout_1[134]:I
*.PININFO rddataout_1[133]:I rddataout_1[132]:I rddataout_1[131]:I rddataout_1[130]:I rddataout_1[129]:I rddataout_1[128]:I rddataout_1[127]:I rddataout_1[126]:I rddataout_1[125]:I rddataout_1[124]:I rddataout_1[123]:I rddataout_1[122]:I rddataout_1[121]:I rddataout_1[120]:I rddataout_1[119]:I rddataout_1[118]:I rddataout_1[117]:I rddataout_1[116]:I rddataout_1[115]:I rddataout_1[114]:I
*.PININFO rddataout_1[113]:I rddataout_1[112]:I rddataout_1[111]:I rddataout_1[110]:I rddataout_1[109]:I rddataout_1[108]:I rddataout_1[107]:I rddataout_1[106]:I rddataout_1[105]:I rddataout_1[104]:I rddataout_1[103]:I rddataout_1[102]:I rddataout_1[101]:I rddataout_1[100]:I rddataout_1[99]:I rddataout_1[98]:I rddataout_1[97]:I rddataout_1[96]:I rddataout_1[95]:I rddataout_1[94]:I
*.PININFO rddataout_1[93]:I rddataout_1[92]:I rddataout_1[91]:I rddataout_1[90]:I rddataout_1[89]:I rddataout_1[88]:I rddataout_1[87]:I rddataout_1[86]:I rddataout_1[85]:I rddataout_1[84]:I rddataout_1[83]:I rddataout_1[82]:I rddataout_1[81]:I rddataout_1[80]:I rddataout_1[79]:I rddataout_1[78]:I rddataout_1[77]:I rddataout_1[76]:I rddataout_1[75]:I rddataout_1[74]:I
*.PININFO rddataout_1[73]:I rddataout_1[72]:I rddataout_1[71]:I rddataout_1[70]:I rddataout_1[69]:I rddataout_1[68]:I rddataout_1[67]:I rddataout_1[66]:I rddataout_1[65]:I rddataout_1[64]:I rddataout_1[63]:I rddataout_1[62]:I rddataout_1[61]:I rddataout_1[60]:I rddataout_1[59]:I rddataout_1[58]:I rddataout_1[57]:I rddataout_1[56]:I rddataout_1[55]:I rddataout_1[54]:I
*.PININFO rddataout_1[53]:I rddataout_1[52]:I rddataout_1[51]:I rddataout_1[50]:I rddataout_1[49]:I rddataout_1[48]:I rddataout_1[47]:I rddataout_1[46]:I rddataout_1[45]:I rddataout_1[44]:I rddataout_1[43]:I rddataout_1[42]:I rddataout_1[41]:I rddataout_1[40]:I rddataout_1[39]:I rddataout_1[38]:I rddataout_1[37]:I rddataout_1[36]:I rddataout_1[35]:I rddataout_1[34]:I
*.PININFO rddataout_1[33]:I rddataout_1[32]:I rddataout_1[31]:I rddataout_1[30]:I rddataout_1[29]:I rddataout_1[28]:I rddataout_1[27]:I rddataout_1[26]:I rddataout_1[25]:I rddataout_1[24]:I rddataout_1[23]:I rddataout_1[22]:I rddataout_1[21]:I rddataout_1[20]:I rddataout_1[19]:I rddataout_1[18]:I rddataout_1[17]:I rddataout_1[16]:I rddataout_1[15]:I rddataout_1[14]:I
*.PININFO rddataout_1[13]:I rddataout_1[12]:I rddataout_1[11]:I rddataout_1[10]:I rddataout_1[9]:I rddataout_1[8]:I rddataout_1[7]:I rddataout_1[6]:I rddataout_1[5]:I rddataout_1[4]:I rddataout_1[3]:I rddataout_1[2]:I rddataout_1[1]:I rddataout_1[0]:I sideen[0]:O turbomode:I turbomode#:O vcc:I vss:I wayselbnk[3]:O
*.PININFO wayselbnk[2]:O wayselbnk[1]:O wayselbnk[0]:O
Xgiocntrl activered#[1] activered#[0] bankgrant1h[1] bankgrant1h[0] bankgrant1l[1]
+ bankgrant1l[0] bankgrant2h[1] bankgrant2h[0] clk clkbank clkrdsync_dn clkrdsync_up
+ clkwr2h2l_dn clkwr2h2l_up fz_asynckick fz_asynckick# fz_asyncrd fz_asyncrd# fz_asyncwr
+ fz_asyncwr# fz_clkgate fz_finekick[3] fz_finekick[2] fz_finekick[1] fz_finekick[0]
+ fz_finekick#[3] fz_finekick#[2] fz_finekick#[1] fz_finekick#[0] fz_rassel[2] fz_rassel[1]
+ fz_rassel[0] fz_rassel#[2] fz_rassel#[1] fz_rassel#[0] fz_rdwlcut fz_rdwlcut#
+ fz_rdwlpw[3] fz_rdwlpw[2] fz_rdwlpw[1] fz_rdwlpw[0] fz_rdwlpw#[3] fz_rdwlpw#[2]
+ fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw[1] fz_saepw[0] fz_saepw#[1] fz_saepw#[0]
+ fz_trbwassel[2] fz_trbwassel[1] fz_trbwassel[0] fz_trbwassel#[2] fz_trbwassel#[1]
+ fz_trbwassel#[0] fz_trkwllvl[2] fz_trkwllvl[1] fz_trkwllvl[0] fz_trkwllvl#[2]
+ fz_trkwllvl#[1] fz_trkwllvl#[0] fz_wassel[2] fz_wassel[1] fz_wassel[0] fz_wassel#[2]
+ fz_wassel#[1] fz_wassel#[0] fz_wrwlcut fz_wrwlcut# fz_wrwlpw[1] fz_wrwlpw[0] fz_wrwlpw#[1]
+ fz_wrwlpw#[0] grant ia[8] ia[7] ia[6] ia[5] ia[4] ia[3] ia[2] ia[1] ia[0] ia_hi#[2]
+ ia_hi#[1] ia_hi#[0] ia_mid#[2] ia_mid#[1] ia_mid#[0] ia_wle#[1] ia_wle#[0] irowredun[1]
+ irowredun[0] iway[7] iway[6] iway[5] iway[4] iway[3] iway[2] iway[1] iway[0] iwen
+ iwren1h iwren1l2l iwren2h3h lyabnk lyaclkstop lyaen lyanowl lyanowl# lyaselgio
+ lyaseltmr selbnk0nn_dn selbnk0nn_up selbnk1nn_dn selbnk1nn_up sideen[0] turbomode
+ turbomode# vcc vss wayselbnk[3] wayselbnk[2] wayselbnk[1] wayselbnk[0] ip78d6hcf2sr4096x135m4i2k4w8r2lya_giocntrl
Xitrkgioslc lyal1bl lyal1blnn lyal2bl lyal2blnn lyaselgio vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_trkgioslc
Xgiobank[1] clkrdsync_up clkwr2h2l_up idin[134] idin[133] idin[132] idin[131] idin[130]
+ idin[129] idin[128] idin[127] idin[126] idin[125] idin[124] idin[123] idin[122]
+ idin[121] idin[120] idin[119] idin[118] idin[117] idin[116] idin[115] idin[114]
+ idin[113] idin[112] idin[111] idin[110] idin[109] idin[108] idin[107] idin[106]
+ idin[105] idin[104] idin[103] idin[102] idin[101] idin[100] idin[99] idin[98]
+ idin[97] idin[96] idin[95] idin[94] idin[93] idin[92] idin[91] idin[90] idin[89]
+ idin[88] idin[87] idin[86] idin[85] idin[84] idin[83] idin[82] idin[81] idin[80]
+ idin[79] idin[78] idin[77] idin[76] idin[75] idin[74] idin[73] idin[72] idin[71]
+ idin[70] idin[69] idin[68] idin1l[134] idin1l[133] idin1l[132] idin1l[131] idin1l[130]
+ idin1l[129] idin1l[128] idin1l[127] idin1l[126] idin1l[125] idin1l[124] idin1l[123]
+ idin1l[122] idin1l[121] idin1l[120] idin1l[119] idin1l[118] idin1l[117] idin1l[116]
+ idin1l[115] idin1l[114] idin1l[113] idin1l[112] idin1l[111] idin1l[110] idin1l[109]
+ idin1l[108] idin1l[107] idin1l[106] idin1l[105] idin1l[104] idin1l[103] idin1l[102]
+ idin1l[101] idin1l[100] idin1l[99] idin1l[98] idin1l[97] idin1l[96] idin1l[95]
+ idin1l[94] idin1l[93] idin1l[92] idin1l[91] idin1l[90] idin1l[89] idin1l[88] idin1l[87]
+ idin1l[86] idin1l[85] idin1l[84] idin1l[83] idin1l[82] idin1l[81] idin1l[80] idin1l[79]
+ idin1l[78] idin1l[77] idin1l[76] idin1l[75] idin1l[74] idin1l[73] idin1l[72] idin1l[71]
+ idin1l[70] idin1l[69] idin1l[68] lyal0bl[134] lyal0bl[133] lyal0bl[132] lyal0bl[131]
+ lyal0bl[130] lyal0bl[129] lyal0bl[128] lyal0bl[127] lyal0bl[126] lyal0bl[125]
+ lyal0bl[124] lyal0bl[123] lyal0bl[122] lyal0bl[121] lyal0bl[120] lyal0bl[119]
+ lyal0bl[118] lyal0bl[117] lyal0bl[116] lyal0bl[115] lyal0bl[114] lyal0bl[113]
+ lyal0bl[112] lyal0bl[111] lyal0bl[110] lyal0bl[109] lyal0bl[108] lyal0bl[107]
+ lyal0bl[106] lyal0bl[105] lyal0bl[104] lyal0bl[103] lyal0bl[102] lyal0bl[101]
+ lyal0bl[100] lyal0bl[99] lyal0bl[98] lyal0bl[97] lyal0bl[96] lyal0bl[95] lyal0bl[94]
+ lyal0bl[93] lyal0bl[92] lyal0bl[91] lyal0bl[90] lyal0bl[89] lyal0bl[88] lyal0bl[87]
+ lyal0bl[86] lyal0bl[85] lyal0bl[84] lyal0bl[83] lyal0bl[82] lyal0bl[81] lyal0bl[80]
+ lyal0bl[79] lyal0bl[78] lyal0bl[77] lyal0bl[76] lyal0bl[75] lyal0bl[74] lyal0bl[73]
+ lyal0bl[72] lyal0bl[71] lyal0bl[70] lyal0bl[69] lyal0bl[68] lyal0blnn[134] lyal0blnn[133]
+ lyal0blnn[132] lyal0blnn[131] lyal0blnn[130] lyal0blnn[129] lyal0blnn[128] lyal0blnn[127]
+ lyal0blnn[126] lyal0blnn[125] lyal0blnn[124] lyal0blnn[123] lyal0blnn[122] lyal0blnn[121]
+ lyal0blnn[120] lyal0blnn[119] lyal0blnn[118] lyal0blnn[117] lyal0blnn[116] lyal0blnn[115]
+ lyal0blnn[114] lyal0blnn[113] lyal0blnn[112] lyal0blnn[111] lyal0blnn[110] lyal0blnn[109]
+ lyal0blnn[108] lyal0blnn[107] lyal0blnn[106] lyal0blnn[105] lyal0blnn[104] lyal0blnn[103]
+ lyal0blnn[102] lyal0blnn[101] lyal0blnn[100] lyal0blnn[99] lyal0blnn[98] lyal0blnn[97]
+ lyal0blnn[96] lyal0blnn[95] lyal0blnn[94] lyal0blnn[93] lyal0blnn[92] lyal0blnn[91]
+ lyal0blnn[90] lyal0blnn[89] lyal0blnn[88] lyal0blnn[87] lyal0blnn[86] lyal0blnn[85]
+ lyal0blnn[84] lyal0blnn[83] lyal0blnn[82] lyal0blnn[81] lyal0blnn[80] lyal0blnn[79]
+ lyal0blnn[78] lyal0blnn[77] lyal0blnn[76] lyal0blnn[75] lyal0blnn[74] lyal0blnn[73]
+ lyal0blnn[72] lyal0blnn[71] lyal0blnn[70] lyal0blnn[69] lyal0blnn[68] lyal1bl
+ lyal1blnn lyaselgio odout[134] odout[133] odout[132] odout[131] odout[130] odout[129]
+ odout[128] odout[127] odout[126] odout[125] odout[124] odout[123] odout[122] odout[121]
+ odout[120] odout[119] odout[118] odout[117] odout[116] odout[115] odout[114] odout[113]
+ odout[112] odout[111] odout[110] odout[109] odout[108] odout[107] odout[106] odout[105]
+ odout[104] odout[103] odout[102] odout[101] odout[100] odout[99] odout[98] odout[97]
+ odout[96] odout[95] odout[94] odout[93] odout[92] odout[91] odout[90] odout[89]
+ odout[88] odout[87] odout[86] odout[85] odout[84] odout[83] odout[82] odout[81]
+ odout[80] odout[79] odout[78] odout[77] odout[76] odout[75] odout[74] odout[73]
+ odout[72] odout[71] odout[70] odout[69] odout[68] rddataout_0[134] rddataout_0[133]
+ rddataout_0[132] rddataout_0[131] rddataout_0[130] rddataout_0[129] rddataout_0[128]
+ rddataout_0[127] rddataout_0[126] rddataout_0[125] rddataout_0[124] rddataout_0[123]
+ rddataout_0[122] rddataout_0[121] rddataout_0[120] rddataout_0[119] rddataout_0[118]
+ rddataout_0[117] rddataout_0[116] rddataout_0[115] rddataout_0[114] rddataout_0[113]
+ rddataout_0[112] rddataout_0[111] rddataout_0[110] rddataout_0[109] rddataout_0[108]
+ rddataout_0[107] rddataout_0[106] rddataout_0[105] rddataout_0[104] rddataout_0[103]
+ rddataout_0[102] rddataout_0[101] rddataout_0[100] rddataout_0[99] rddataout_0[98]
+ rddataout_0[97] rddataout_0[96] rddataout_0[95] rddataout_0[94] rddataout_0[93]
+ rddataout_0[92] rddataout_0[91] rddataout_0[90] rddataout_0[89] rddataout_0[88]
+ rddataout_0[87] rddataout_0[86] rddataout_0[85] rddataout_0[84] rddataout_0[83]
+ rddataout_0[82] rddataout_0[81] rddataout_0[80] rddataout_0[79] rddataout_0[78]
+ rddataout_0[77] rddataout_0[76] rddataout_0[75] rddataout_0[74] rddataout_0[73]
+ rddataout_0[72] rddataout_0[71] rddataout_0[70] rddataout_0[69] rddataout_0[68]
+ rddataout_1[134] rddataout_1[133] rddataout_1[132] rddataout_1[131] rddataout_1[130]
+ rddataout_1[129] rddataout_1[128] rddataout_1[127] rddataout_1[126] rddataout_1[125]
+ rddataout_1[124] rddataout_1[123] rddataout_1[122] rddataout_1[121] rddataout_1[120]
+ rddataout_1[119] rddataout_1[118] rddataout_1[117] rddataout_1[116] rddataout_1[115]
+ rddataout_1[114] rddataout_1[113] rddataout_1[112] rddataout_1[111] rddataout_1[110]
+ rddataout_1[109] rddataout_1[108] rddataout_1[107] rddataout_1[106] rddataout_1[105]
+ rddataout_1[104] rddataout_1[103] rddataout_1[102] rddataout_1[101] rddataout_1[100]
+ rddataout_1[99] rddataout_1[98] rddataout_1[97] rddataout_1[96] rddataout_1[95]
+ rddataout_1[94] rddataout_1[93] rddataout_1[92] rddataout_1[91] rddataout_1[90]
+ rddataout_1[89] rddataout_1[88] rddataout_1[87] rddataout_1[86] rddataout_1[85]
+ rddataout_1[84] rddataout_1[83] rddataout_1[82] rddataout_1[81] rddataout_1[80]
+ rddataout_1[79] rddataout_1[78] rddataout_1[77] rddataout_1[76] rddataout_1[75]
+ rddataout_1[74] rddataout_1[73] rddataout_1[72] rddataout_1[71] rddataout_1[70]
+ rddataout_1[69] rddataout_1[68] selbnk0nn_up selbnk1nn_up vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_sramgiobank_up
Xgiobank[0] clkrdsync_dn clkwr2h2l_dn idin[67] idin[66] idin[65] idin[64] idin[63]
+ idin[62] idin[61] idin[60] idin[59] idin[58] idin[57] idin[56] idin[55] idin[54]
+ idin[53] idin[52] idin[51] idin[50] idin[49] idin[48] idin[47] idin[46] idin[45]
+ idin[44] idin[43] idin[42] idin[41] idin[40] idin[39] idin[38] idin[37] idin[36]
+ idin[35] idin[34] idin[33] idin[32] idin[31] idin[30] idin[29] idin[28] idin[27]
+ idin[26] idin[25] idin[24] idin[23] idin[22] idin[21] idin[20] idin[19] idin[18]
+ idin[17] idin[16] idin[15] idin[14] idin[13] idin[12] idin[11] idin[10] idin[9]
+ idin[8] idin[7] idin[6] idin[5] idin[4] idin[3] idin[2] idin[1] idin[0] idin1l[67]
+ idin1l[66] idin1l[65] idin1l[64] idin1l[63] idin1l[62] idin1l[61] idin1l[60] idin1l[59]
+ idin1l[58] idin1l[57] idin1l[56] idin1l[55] idin1l[54] idin1l[53] idin1l[52] idin1l[51]
+ idin1l[50] idin1l[49] idin1l[48] idin1l[47] idin1l[46] idin1l[45] idin1l[44] idin1l[43]
+ idin1l[42] idin1l[41] idin1l[40] idin1l[39] idin1l[38] idin1l[37] idin1l[36] idin1l[35]
+ idin1l[34] idin1l[33] idin1l[32] idin1l[31] idin1l[30] idin1l[29] idin1l[28] idin1l[27]
+ idin1l[26] idin1l[25] idin1l[24] idin1l[23] idin1l[22] idin1l[21] idin1l[20] idin1l[19]
+ idin1l[18] idin1l[17] idin1l[16] idin1l[15] idin1l[14] idin1l[13] idin1l[12] idin1l[11]
+ idin1l[10] idin1l[9] idin1l[8] idin1l[7] idin1l[6] idin1l[5] idin1l[4] idin1l[3]
+ idin1l[2] idin1l[1] idin1l[0] lyal0bl[67] lyal0bl[66] lyal0bl[65] lyal0bl[64]
+ lyal0bl[63] lyal0bl[62] lyal0bl[61] lyal0bl[60] lyal0bl[59] lyal0bl[58] lyal0bl[57]
+ lyal0bl[56] lyal0bl[55] lyal0bl[54] lyal0bl[53] lyal0bl[52] lyal0bl[51] lyal0bl[50]
+ lyal0bl[49] lyal0bl[48] lyal0bl[47] lyal0bl[46] lyal0bl[45] lyal0bl[44] lyal0bl[43]
+ lyal0bl[42] lyal0bl[41] lyal0bl[40] lyal0bl[39] lyal0bl[38] lyal0bl[37] lyal0bl[36]
+ lyal0bl[35] lyal0bl[34] lyal0bl[33] lyal0bl[32] lyal0bl[31] lyal0bl[30] lyal0bl[29]
+ lyal0bl[28] lyal0bl[27] lyal0bl[26] lyal0bl[25] lyal0bl[24] lyal0bl[23] lyal0bl[22]
+ lyal0bl[21] lyal0bl[20] lyal0bl[19] lyal0bl[18] lyal0bl[17] lyal0bl[16] lyal0bl[15]
+ lyal0bl[14] lyal0bl[13] lyal0bl[12] lyal0bl[11] lyal0bl[10] lyal0bl[9] lyal0bl[8]
+ lyal0bl[7] lyal0bl[6] lyal0bl[5] lyal0bl[4] lyal0bl[3] lyal0bl[2] lyal0bl[1] lyal0bl[0]
+ lyal0blnn[67] lyal0blnn[66] lyal0blnn[65] lyal0blnn[64] lyal0blnn[63] lyal0blnn[62]
+ lyal0blnn[61] lyal0blnn[60] lyal0blnn[59] lyal0blnn[58] lyal0blnn[57] lyal0blnn[56]
+ lyal0blnn[55] lyal0blnn[54] lyal0blnn[53] lyal0blnn[52] lyal0blnn[51] lyal0blnn[50]
+ lyal0blnn[49] lyal0blnn[48] lyal0blnn[47] lyal0blnn[46] lyal0blnn[45] lyal0blnn[44]
+ lyal0blnn[43] lyal0blnn[42] lyal0blnn[41] lyal0blnn[40] lyal0blnn[39] lyal0blnn[38]
+ lyal0blnn[37] lyal0blnn[36] lyal0blnn[35] lyal0blnn[34] lyal0blnn[33] lyal0blnn[32]
+ lyal0blnn[31] lyal0blnn[30] lyal0blnn[29] lyal0blnn[28] lyal0blnn[27] lyal0blnn[26]
+ lyal0blnn[25] lyal0blnn[24] lyal0blnn[23] lyal0blnn[22] lyal0blnn[21] lyal0blnn[20]
+ lyal0blnn[19] lyal0blnn[18] lyal0blnn[17] lyal0blnn[16] lyal0blnn[15] lyal0blnn[14]
+ lyal0blnn[13] lyal0blnn[12] lyal0blnn[11] lyal0blnn[10] lyal0blnn[9] lyal0blnn[8]
+ lyal0blnn[7] lyal0blnn[6] lyal0blnn[5] lyal0blnn[4] lyal0blnn[3] lyal0blnn[2]
+ lyal0blnn[1] lyal0blnn[0] lyal1bl lyal1blnn lyaselgio odout[67] odout[66] odout[65]
+ odout[64] odout[63] odout[62] odout[61] odout[60] odout[59] odout[58] odout[57]
+ odout[56] odout[55] odout[54] odout[53] odout[52] odout[51] odout[50] odout[49]
+ odout[48] odout[47] odout[46] odout[45] odout[44] odout[43] odout[42] odout[41]
+ odout[40] odout[39] odout[38] odout[37] odout[36] odout[35] odout[34] odout[33]
+ odout[32] odout[31] odout[30] odout[29] odout[28] odout[27] odout[26] odout[25]
+ odout[24] odout[23] odout[22] odout[21] odout[20] odout[19] odout[18] odout[17]
+ odout[16] odout[15] odout[14] odout[13] odout[12] odout[11] odout[10] odout[9]
+ odout[8] odout[7] odout[6] odout[5] odout[4] odout[3] odout[2] odout[1] odout[0]
+ rddataout_0[67] rddataout_0[66] rddataout_0[65] rddataout_0[64] rddataout_0[63]
+ rddataout_0[62] rddataout_0[61] rddataout_0[60] rddataout_0[59] rddataout_0[58]
+ rddataout_0[57] rddataout_0[56] rddataout_0[55] rddataout_0[54] rddataout_0[53]
+ rddataout_0[52] rddataout_0[51] rddataout_0[50] rddataout_0[49] rddataout_0[48]
+ rddataout_0[47] rddataout_0[46] rddataout_0[45] rddataout_0[44] rddataout_0[43]
+ rddataout_0[42] rddataout_0[41] rddataout_0[40] rddataout_0[39] rddataout_0[38]
+ rddataout_0[37] rddataout_0[36] rddataout_0[35] rddataout_0[34] rddataout_0[33]
+ rddataout_0[32] rddataout_0[31] rddataout_0[30] rddataout_0[29] rddataout_0[28]
+ rddataout_0[27] rddataout_0[26] rddataout_0[25] rddataout_0[24] rddataout_0[23]
+ rddataout_0[22] rddataout_0[21] rddataout_0[20] rddataout_0[19] rddataout_0[18]
+ rddataout_0[17] rddataout_0[16] rddataout_0[15] rddataout_0[14] rddataout_0[13]
+ rddataout_0[12] rddataout_0[11] rddataout_0[10] rddataout_0[9] rddataout_0[8]
+ rddataout_0[7] rddataout_0[6] rddataout_0[5] rddataout_0[4] rddataout_0[3] rddataout_0[2]
+ rddataout_0[1] rddataout_0[0] rddataout_1[67] rddataout_1[66] rddataout_1[65]
+ rddataout_1[64] rddataout_1[63] rddataout_1[62] rddataout_1[61] rddataout_1[60]
+ rddataout_1[59] rddataout_1[58] rddataout_1[57] rddataout_1[56] rddataout_1[55]
+ rddataout_1[54] rddataout_1[53] rddataout_1[52] rddataout_1[51] rddataout_1[50]
+ rddataout_1[49] rddataout_1[48] rddataout_1[47] rddataout_1[46] rddataout_1[45]
+ rddataout_1[44] rddataout_1[43] rddataout_1[42] rddataout_1[41] rddataout_1[40]
+ rddataout_1[39] rddataout_1[38] rddataout_1[37] rddataout_1[36] rddataout_1[35]
+ rddataout_1[34] rddataout_1[33] rddataout_1[32] rddataout_1[31] rddataout_1[30]
+ rddataout_1[29] rddataout_1[28] rddataout_1[27] rddataout_1[26] rddataout_1[25]
+ rddataout_1[24] rddataout_1[23] rddataout_1[22] rddataout_1[21] rddataout_1[20]
+ rddataout_1[19] rddataout_1[18] rddataout_1[17] rddataout_1[16] rddataout_1[15]
+ rddataout_1[14] rddataout_1[13] rddataout_1[12] rddataout_1[11] rddataout_1[10]
+ rddataout_1[9] rddataout_1[8] rddataout_1[7] rddataout_1[6] rddataout_1[5] rddataout_1[4]
+ rddataout_1[3] rddataout_1[2] rddataout_1[1] rddataout_1[0] selbnk0nn_dn selbnk1nn_dn
+ vcc vss ip78d6hcf2sr4096x135m4i2k4w8r2lya_sramgiobank_dn
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_sliceio bl0[3] bl0[2] bl0[1] bl0[0] bl1[3]
+ bl1[2] bl1[1] bl1[0] blnn0[3] blnn0[2] blnn0[1] blnn0[0] blnn1[3] blnn1[2] blnn1[1]
+ blnn1[0] idin[0] lyaennn lyal0bl lyal0blnn nbl_kicknn pcnn0 pcnn1 rddataout[0]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ saenn sapchnn vcc vss waenn[2] waenn[1] waenn[0] wrclk wrcolsel0[3] wrcolsel0[2]
+ wrcolsel0[1] wrcolsel0[0] wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0]
+ wrdataen
*.PININFO bl0[3]:B bl0[2]:B bl0[1]:B bl0[0]:B bl1[3]:B bl1[2]:B bl1[1]:B bl1[0]:B blnn0[3]:B blnn0[2]:B blnn0[1]:B blnn0[0]:B blnn1[3]:B blnn1[2]:B blnn1[1]:B blnn1[0]:B idin[0]:I lyaennn:I lyal0bl:I lyal0blnn:I
*.PININFO nbl_kicknn:I pcnn0:I pcnn1:I rddataout[0]:O rdysel0[3]:I rdysel0[2]:I rdysel0[1]:I rdysel0[0]:I rdysel1[3]:I rdysel1[2]:I rdysel1[1]:I rdysel1[0]:I saenn:I sapchnn:I vcc:I vss:I waenn[2]:I waenn[1]:I waenn[0]:I wrclk:I
*.PININFO wrcolsel0[3]:I wrcolsel0[2]:I wrcolsel0[1]:I wrcolsel0[0]:I wrcolsel1[3]:I wrcolsel1[2]:I wrcolsel1[1]:I wrcolsel1[0]:I wrdataen:I
Xcenio decnvss[0] idin[0] inbl[0] inblnn[0] lyaenbit lyaennn nbl_kicknn nocon_ncg2[0]
+ nvss[0] rddataout[0] saenn sapchnn vcc vss waenn[2] waenn[1] waenn[0] wrclk wrdata[0]
+ wrdataen wrdatann[0] issahccciocm4
Xsideio0 bl0[3] bl0[2] bl0[1] bl0[0] blnn0[3] blnn0[2] blnn0[1] blnn0[0] decnvss[0]
+ inbl[0] inblnn[0] lyaenbit lyal0bl lyal0blnn nvss[0] pcnn0 rdysel0[3] rdysel0[2]
+ rdysel0[1] rdysel0[0] vcc vss wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrdata[0] wrdatann[0] issahccsiocm4lya
Xsideio1 bl1[3] bl1[2] bl1[1] bl1[0] blnn1[3] blnn1[2] blnn1[1] blnn1[0] decnvss[0]
+ inbl[0] inblnn[0] lyaenbit lyal0bl lyal0blnn nvss[0] pcnn1 rdysel1[3] rdysel1[2]
+ rdysel1[1] rdysel1[0] vcc vss wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0]
+ wrdata[0] wrdatann[0] issahccsiocm4lya
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issax2deci128
* View Name:    schematic
************************************************************************
.SUBCKT issax2deci128 c6saveb c6savet decvccb decvcct hi[3] hi[2] hi[1] hi[0] mid[7]
+ mid[6] mid[5] mid[4] mid[3] mid[2] mid[1] mid[0] slpen[0] slpennn vcc vssx wlb[127]
+ wlb[126] wlb[125] wlb[124] wlb[123] wlb[122] wlb[121] wlb[120] wlb[119] wlb[118]
+ wlb[117] wlb[116] wlb[115] wlb[114] wlb[113] wlb[112] wlb[111] wlb[110] wlb[109]
+ wlb[108] wlb[107] wlb[106] wlb[105] wlb[104] wlb[103] wlb[102] wlb[101] wlb[100]
+ wlb[99] wlb[98] wlb[97] wlb[96] wlb[95] wlb[94] wlb[93] wlb[92] wlb[91] wlb[90]
+ wlb[89] wlb[88] wlb[87] wlb[86] wlb[85] wlb[84] wlb[83] wlb[82] wlb[81] wlb[80]
+ wlb[79] wlb[78] wlb[77] wlb[76] wlb[75] wlb[74] wlb[73] wlb[72] wlb[71] wlb[70]
+ wlb[69] wlb[68] wlb[67] wlb[66] wlb[65] wlb[64] wlb[63] wlb[62] wlb[61] wlb[60]
+ wlb[59] wlb[58] wlb[57] wlb[56] wlb[55] wlb[54] wlb[53] wlb[52] wlb[51] wlb[50]
+ wlb[49] wlb[48] wlb[47] wlb[46] wlb[45] wlb[44] wlb[43] wlb[42] wlb[41] wlb[40]
+ wlb[39] wlb[38] wlb[37] wlb[36] wlb[35] wlb[34] wlb[33] wlb[32] wlb[31] wlb[30]
+ wlb[29] wlb[28] wlb[27] wlb[26] wlb[25] wlb[24] wlb[23] wlb[22] wlb[21] wlb[20]
+ wlb[19] wlb[18] wlb[17] wlb[16] wlb[15] wlb[14] wlb[13] wlb[12] wlb[11] wlb[10]
+ wlb[9] wlb[8] wlb[7] wlb[6] wlb[5] wlb[4] wlb[3] wlb[2] wlb[1] wlb[0] wlenn[3]
+ wlenn[2] wlenn[1] wlenn[0] wllvl[2] wllvl[1] wllvl[0] wllvlnn0[2] wllvlnn0[1]
+ wllvlnn0[0] wlt[127] wlt[126] wlt[125] wlt[124] wlt[123] wlt[122] wlt[121] wlt[120]
+ wlt[119] wlt[118] wlt[117] wlt[116] wlt[115] wlt[114] wlt[113] wlt[112] wlt[111]
+ wlt[110] wlt[109] wlt[108] wlt[107] wlt[106] wlt[105] wlt[104] wlt[103] wlt[102]
+ wlt[101] wlt[100] wlt[99] wlt[98] wlt[97] wlt[96] wlt[95] wlt[94] wlt[93] wlt[92]
+ wlt[91] wlt[90] wlt[89] wlt[88] wlt[87] wlt[86] wlt[85] wlt[84] wlt[83] wlt[82]
+ wlt[81] wlt[80] wlt[79] wlt[78] wlt[77] wlt[76] wlt[75] wlt[74] wlt[73] wlt[72]
+ wlt[71] wlt[70] wlt[69] wlt[68] wlt[67] wlt[66] wlt[65] wlt[64] wlt[63] wlt[62]
+ wlt[61] wlt[60] wlt[59] wlt[58] wlt[57] wlt[56] wlt[55] wlt[54] wlt[53] wlt[52]
+ wlt[51] wlt[50] wlt[49] wlt[48] wlt[47] wlt[46] wlt[45] wlt[44] wlt[43] wlt[42]
+ wlt[41] wlt[40] wlt[39] wlt[38] wlt[37] wlt[36] wlt[35] wlt[34] wlt[33] wlt[32]
+ wlt[31] wlt[30] wlt[29] wlt[28] wlt[27] wlt[26] wlt[25] wlt[24] wlt[23] wlt[22]
+ wlt[21] wlt[20] wlt[19] wlt[18] wlt[17] wlt[16] wlt[15] wlt[14] wlt[13] wlt[12]
+ wlt[11] wlt[10] wlt[9] wlt[8] wlt[7] wlt[6] wlt[5] wlt[4] wlt[3] wlt[2] wlt[1]
+ wlt[0]
*.PININFO c6saveb:I c6savet:I decvccb:B decvcct:B hi[3]:I hi[2]:I hi[1]:I hi[0]:I mid[7]:I mid[6]:I mid[5]:I mid[4]:I mid[3]:I mid[2]:I mid[1]:I mid[0]:I slpen[0]:O slpennn:I vcc:I vssx:I
*.PININFO wlb[127]:O wlb[126]:O wlb[125]:O wlb[124]:O wlb[123]:O wlb[122]:O wlb[121]:O wlb[120]:O wlb[119]:O wlb[118]:O wlb[117]:O wlb[116]:O wlb[115]:O wlb[114]:O wlb[113]:O wlb[112]:O wlb[111]:O wlb[110]:O wlb[109]:O wlb[108]:O
*.PININFO wlb[107]:O wlb[106]:O wlb[105]:O wlb[104]:O wlb[103]:O wlb[102]:O wlb[101]:O wlb[100]:O wlb[99]:O wlb[98]:O wlb[97]:O wlb[96]:O wlb[95]:O wlb[94]:O wlb[93]:O wlb[92]:O wlb[91]:O wlb[90]:O wlb[89]:O wlb[88]:O
*.PININFO wlb[87]:O wlb[86]:O wlb[85]:O wlb[84]:O wlb[83]:O wlb[82]:O wlb[81]:O wlb[80]:O wlb[79]:O wlb[78]:O wlb[77]:O wlb[76]:O wlb[75]:O wlb[74]:O wlb[73]:O wlb[72]:O wlb[71]:O wlb[70]:O wlb[69]:O wlb[68]:O
*.PININFO wlb[67]:O wlb[66]:O wlb[65]:O wlb[64]:O wlb[63]:O wlb[62]:O wlb[61]:O wlb[60]:O wlb[59]:O wlb[58]:O wlb[57]:O wlb[56]:O wlb[55]:O wlb[54]:O wlb[53]:O wlb[52]:O wlb[51]:O wlb[50]:O wlb[49]:O wlb[48]:O
*.PININFO wlb[47]:O wlb[46]:O wlb[45]:O wlb[44]:O wlb[43]:O wlb[42]:O wlb[41]:O wlb[40]:O wlb[39]:O wlb[38]:O wlb[37]:O wlb[36]:O wlb[35]:O wlb[34]:O wlb[33]:O wlb[32]:O wlb[31]:O wlb[30]:O wlb[29]:O wlb[28]:O
*.PININFO wlb[27]:O wlb[26]:O wlb[25]:O wlb[24]:O wlb[23]:O wlb[22]:O wlb[21]:O wlb[20]:O wlb[19]:O wlb[18]:O wlb[17]:O wlb[16]:O wlb[15]:O wlb[14]:O wlb[13]:O wlb[12]:O wlb[11]:O wlb[10]:O wlb[9]:O wlb[8]:O
*.PININFO wlb[7]:O wlb[6]:O wlb[5]:O wlb[4]:O wlb[3]:O wlb[2]:O wlb[1]:O wlb[0]:O wlenn[3]:I wlenn[2]:I wlenn[1]:I wlenn[0]:I wllvl[2]:I wllvl[1]:I wllvl[0]:I wllvlnn0[2]:O wllvlnn0[1]:O wllvlnn0[0]:O wlt[127]:O wlt[126]:O
*.PININFO wlt[125]:O wlt[124]:O wlt[123]:O wlt[122]:O wlt[121]:O wlt[120]:O wlt[119]:O wlt[118]:O wlt[117]:O wlt[116]:O wlt[115]:O wlt[114]:O wlt[113]:O wlt[112]:O wlt[111]:O wlt[110]:O wlt[109]:O wlt[108]:O wlt[107]:O wlt[106]:O
*.PININFO wlt[105]:O wlt[104]:O wlt[103]:O wlt[102]:O wlt[101]:O wlt[100]:O wlt[99]:O wlt[98]:O wlt[97]:O wlt[96]:O wlt[95]:O wlt[94]:O wlt[93]:O wlt[92]:O wlt[91]:O wlt[90]:O wlt[89]:O wlt[88]:O wlt[87]:O wlt[86]:O
*.PININFO wlt[85]:O wlt[84]:O wlt[83]:O wlt[82]:O wlt[81]:O wlt[80]:O wlt[79]:O wlt[78]:O wlt[77]:O wlt[76]:O wlt[75]:O wlt[74]:O wlt[73]:O wlt[72]:O wlt[71]:O wlt[70]:O wlt[69]:O wlt[68]:O wlt[67]:O wlt[66]:O
*.PININFO wlt[65]:O wlt[64]:O wlt[63]:O wlt[62]:O wlt[61]:O wlt[60]:O wlt[59]:O wlt[58]:O wlt[57]:O wlt[56]:O wlt[55]:O wlt[54]:O wlt[53]:O wlt[52]:O wlt[51]:O wlt[50]:O wlt[49]:O wlt[48]:O wlt[47]:O wlt[46]:O
*.PININFO wlt[45]:O wlt[44]:O wlt[43]:O wlt[42]:O wlt[41]:O wlt[40]:O wlt[39]:O wlt[38]:O wlt[37]:O wlt[36]:O wlt[35]:O wlt[34]:O wlt[33]:O wlt[32]:O wlt[31]:O wlt[30]:O wlt[29]:O wlt[28]:O wlt[27]:O wlt[26]:O
*.PININFO wlt[25]:O wlt[24]:O wlt[23]:O wlt[22]:O wlt[21]:O wlt[20]:O wlt[19]:O wlt[18]:O wlt[17]:O wlt[16]:O wlt[15]:O wlt[14]:O wlt[13]:O wlt[12]:O wlt[11]:O wlt[10]:O wlt[9]:O wlt[8]:O wlt[7]:O wlt[6]:O
*.PININFO wlt[5]:O wlt[4]:O wlt[3]:O wlt[2]:O wlt[1]:O wlt[0]:O
Xxdec32[3] c6saveb c6savet decvccb decvcct hi[3] mid[7] mid[6] mid[5] mid[4] mid[3]
+ mid[2] mid[1] mid[0] slpen[3] slpennn vcc vssx wlb[127] wlb[126] wlb[125] wlb[124]
+ wlb[123] wlb[122] wlb[121] wlb[120] wlb[119] wlb[118] wlb[117] wlb[116] wlb[115]
+ wlb[114] wlb[113] wlb[112] wlb[111] wlb[110] wlb[109] wlb[108] wlb[107] wlb[106]
+ wlb[105] wlb[104] wlb[103] wlb[102] wlb[101] wlb[100] wlb[99] wlb[98] wlb[97]
+ wlb[96] wlenn[3] wlenn[2] wlenn[1] wlenn[0] wllvl[2] wllvl[1] wllvl[0] wllvlnn3[2]
+ wllvlnn3[1] wllvlnn3[0] wlt[127] wlt[126] wlt[125] wlt[124] wlt[123] wlt[122]
+ wlt[121] wlt[120] wlt[119] wlt[118] wlt[117] wlt[116] wlt[115] wlt[114] wlt[113]
+ wlt[112] wlt[111] wlt[110] wlt[109] wlt[108] wlt[107] wlt[106] wlt[105] wlt[104]
+ wlt[103] wlt[102] wlt[101] wlt[100] wlt[99] wlt[98] wlt[97] wlt[96] issax2dec32
Xxdec32[2] c6saveb c6savet decvccb decvcct hi[2] mid[7] mid[6] mid[5] mid[4] mid[3]
+ mid[2] mid[1] mid[0] slpen[2] slpennn vcc vssx wlb[95] wlb[94] wlb[93] wlb[92]
+ wlb[91] wlb[90] wlb[89] wlb[88] wlb[87] wlb[86] wlb[85] wlb[84] wlb[83] wlb[82]
+ wlb[81] wlb[80] wlb[79] wlb[78] wlb[77] wlb[76] wlb[75] wlb[74] wlb[73] wlb[72]
+ wlb[71] wlb[70] wlb[69] wlb[68] wlb[67] wlb[66] wlb[65] wlb[64] wlenn[3] wlenn[2]
+ wlenn[1] wlenn[0] wllvl[2] wllvl[1] wllvl[0] wllvlnn2[2] wllvlnn2[1] wllvlnn2[0]
+ wlt[95] wlt[94] wlt[93] wlt[92] wlt[91] wlt[90] wlt[89] wlt[88] wlt[87] wlt[86]
+ wlt[85] wlt[84] wlt[83] wlt[82] wlt[81] wlt[80] wlt[79] wlt[78] wlt[77] wlt[76]
+ wlt[75] wlt[74] wlt[73] wlt[72] wlt[71] wlt[70] wlt[69] wlt[68] wlt[67] wlt[66]
+ wlt[65] wlt[64] issax2dec32
Xxdec32[1] c6saveb c6savet decvccb decvcct hi[1] mid[7] mid[6] mid[5] mid[4] mid[3]
+ mid[2] mid[1] mid[0] slpen[1] slpennn vcc vssx wlb[63] wlb[62] wlb[61] wlb[60]
+ wlb[59] wlb[58] wlb[57] wlb[56] wlb[55] wlb[54] wlb[53] wlb[52] wlb[51] wlb[50]
+ wlb[49] wlb[48] wlb[47] wlb[46] wlb[45] wlb[44] wlb[43] wlb[42] wlb[41] wlb[40]
+ wlb[39] wlb[38] wlb[37] wlb[36] wlb[35] wlb[34] wlb[33] wlb[32] wlenn[3] wlenn[2]
+ wlenn[1] wlenn[0] wllvl[2] wllvl[1] wllvl[0] wllvlnn1[2] wllvlnn1[1] wllvlnn1[0]
+ wlt[63] wlt[62] wlt[61] wlt[60] wlt[59] wlt[58] wlt[57] wlt[56] wlt[55] wlt[54]
+ wlt[53] wlt[52] wlt[51] wlt[50] wlt[49] wlt[48] wlt[47] wlt[46] wlt[45] wlt[44]
+ wlt[43] wlt[42] wlt[41] wlt[40] wlt[39] wlt[38] wlt[37] wlt[36] wlt[35] wlt[34]
+ wlt[33] wlt[32] issax2dec32
Xxdec32[0] c6saveb c6savet decvccb decvcct hi[0] mid[7] mid[6] mid[5] mid[4] mid[3]
+ mid[2] mid[1] mid[0] slpen[0] slpennn vcc vssx wlb[31] wlb[30] wlb[29] wlb[28]
+ wlb[27] wlb[26] wlb[25] wlb[24] wlb[23] wlb[22] wlb[21] wlb[20] wlb[19] wlb[18]
+ wlb[17] wlb[16] wlb[15] wlb[14] wlb[13] wlb[12] wlb[11] wlb[10] wlb[9] wlb[8]
+ wlb[7] wlb[6] wlb[5] wlb[4] wlb[3] wlb[2] wlb[1] wlb[0] wlenn[3] wlenn[2] wlenn[1]
+ wlenn[0] wllvl[2] wllvl[1] wllvl[0] wllvlnn0[2] wllvlnn0[1] wllvlnn0[0] wlt[31]
+ wlt[30] wlt[29] wlt[28] wlt[27] wlt[26] wlt[25] wlt[24] wlt[23] wlt[22] wlt[21]
+ wlt[20] wlt[19] wlt[18] wlt[17] wlt[16] wlt[15] wlt[14] wlt[13] wlt[12] wlt[11]
+ wlt[10] wlt[9] wlt[8] wlt[7] wlt[6] wlt[5] wlt[4] wlt[3] wlt[2] wlt[1] wlt[0] issax2dec32
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccary8x4
* View Name:    schematic
************************************************************************
.SUBCKT issahccary8x4 bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc
+ sramvss wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0]
*.PININFO bl[3]:B bl[2]:B bl[1]:B bl[0]:B bl_b[3]:B bl_b[2]:B bl_b[1]:B bl_b[0]:B sramvcc:I sramvss:I wl[7]:I wl[6]:I wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I
Xiary2x4[3] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[7] wl[6] issahccbit2x4
Xiary2x4[2] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[5] wl[4] issahccbit2x4
Xiary2x4[1] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[3] wl[2] issahccbit2x4
Xiary2x4[0] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[1] wl[0] issahccbit2x4
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccedg1x4
* View Name:    schematic
************************************************************************
.SUBCKT issahccedg1x4 bl[3] bl[2] bl[1] bl[0] sramvcc[3] sramvcc[2] sramvcc[1] sramvcc[0]
+ sramvss
*.PININFO bl[3]:B bl[2]:B bl[1]:B bl[0]:B sramvcc[3]:I sramvcc[2]:I sramvcc[1]:I sramvcc[0]:I sramvss:I
Xibitedge[0] bl[3] bl[2] bl[1] bl[0] sramvcc[3] sramvcc[2] sramvcc[1] sramvcc[0]
+ sramvss issahcc5edg1x4_ru
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccarytrkdrvld128x2
* View Name:    schematic
************************************************************************
.SUBCKT issahccarytrkdrvld128x2 bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn
+ sramvss trkbl trkwl wl[127] wl[126] wl[125] wl[124] wl[123] wl[122] wl[121] wl[120]
+ wl[119] wl[118] wl[117] wl[116] wl[115] wl[114] wl[113] wl[112] wl[111] wl[110]
+ wl[109] wl[108] wl[107] wl[106] wl[105] wl[104] wl[103] wl[102] wl[101] wl[100]
+ wl[99] wl[98] wl[97] wl[96] wl[95] wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88]
+ wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81] wl[80] wl[79] wl[78] wl[77] wl[76]
+ wl[75] wl[74] wl[73] wl[72] wl[71] wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64]
+ wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57] wl[56] wl[55] wl[54] wl[53] wl[52]
+ wl[51] wl[50] wl[49] wl[48] wl[47] wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40]
+ wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33] wl[32] wl[31] wl[30] wl[29] wl[28]
+ wl[27] wl[26] wl[25] wl[24] wl[23] wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16]
+ wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9] wl[8] wl[7] wl[6] wl[5] wl[4]
+ wl[3] wl[2] wl[1] wl[0]
*.PININFO bl_noconn[0]:I noconn[0]:I noconn[1]:I sramvcc:I sramvcc_noconn:I sramvss:I trkbl:B trkwl:I wl[127]:I wl[126]:I wl[125]:I wl[124]:I wl[123]:I wl[122]:I wl[121]:I wl[120]:I wl[119]:I wl[118]:I wl[117]:I wl[116]:I
*.PININFO wl[115]:I wl[114]:I wl[113]:I wl[112]:I wl[111]:I wl[110]:I wl[109]:I wl[108]:I wl[107]:I wl[106]:I wl[105]:I wl[104]:I wl[103]:I wl[102]:I wl[101]:I wl[100]:I wl[99]:I wl[98]:I wl[97]:I wl[96]:I
*.PININFO wl[95]:I wl[94]:I wl[93]:I wl[92]:I wl[91]:I wl[90]:I wl[89]:I wl[88]:I wl[87]:I wl[86]:I wl[85]:I wl[84]:I wl[83]:I wl[82]:I wl[81]:I wl[80]:I wl[79]:I wl[78]:I wl[77]:I wl[76]:I
*.PININFO wl[75]:I wl[74]:I wl[73]:I wl[72]:I wl[71]:I wl[70]:I wl[69]:I wl[68]:I wl[67]:I wl[66]:I wl[65]:I wl[64]:I wl[63]:I wl[62]:I wl[61]:I wl[60]:I wl[59]:I wl[58]:I wl[57]:I wl[56]:I
*.PININFO wl[55]:I wl[54]:I wl[53]:I wl[52]:I wl[51]:I wl[50]:I wl[49]:I wl[48]:I wl[47]:I wl[46]:I wl[45]:I wl[44]:I wl[43]:I wl[42]:I wl[41]:I wl[40]:I wl[39]:I wl[38]:I wl[37]:I wl[36]:I
*.PININFO wl[35]:I wl[34]:I wl[33]:I wl[32]:I wl[31]:I wl[30]:I wl[29]:I wl[28]:I wl[27]:I wl[26]:I wl[25]:I wl[24]:I wl[23]:I wl[22]:I wl[21]:I wl[20]:I wl[19]:I wl[18]:I wl[17]:I wl[16]:I
*.PININFO wl[15]:I wl[14]:I wl[13]:I wl[12]:I wl[11]:I wl[10]:I wl[9]:I wl[8]:I wl[7]:I wl[6]:I wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I
Xiary8x2[14] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[119] wl[118] wl[117] wl[116] wl[115] wl[114] wl[113] wl[112] issahccarytrkld8x2
Xiary8x2[13] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[111] wl[110] wl[109] wl[108] wl[107] wl[106] wl[105] wl[104] issahccarytrkld8x2
Xiary8x2[12] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[103] wl[102] wl[101] wl[100] wl[99] wl[98] wl[97] wl[96] issahccarytrkld8x2
Xiary8x2[11] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[95] wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88] issahccarytrkld8x2
Xiary8x2[10] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81] wl[80] issahccarytrkld8x2
Xiary8x2[9] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[79] wl[78] wl[77] wl[76] wl[75] wl[74] wl[73] wl[72] issahccarytrkld8x2
Xiary8x2[8] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[71] wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64] issahccarytrkld8x2
Xiary8x2[7] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57] wl[56] issahccarytrkld8x2
Xiary8x2[6] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[55] wl[54] wl[53] wl[52] wl[51] wl[50] wl[49] wl[48] issahccarytrkld8x2
Xiary8x2[5] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[47] wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40] issahccarytrkld8x2
Xiary8x2[4] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33] wl[32] issahccarytrkld8x2
Xiary8x2[3] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[31] wl[30] wl[29] wl[28] wl[27] wl[26] wl[25] wl[24] issahccarytrkld8x2
Xiary8x2[2] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[23] wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16] issahccarytrkld8x2
Xiary8x2[1] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9] wl[8] issahccarytrkld8x2
Xiary8x2[0] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0] issahccarytrkld8x2
Xiarydrv8x2 bl_noconn[0] trkwl noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss
+ trkbl wl[127] wl[126] wl[125] wl[124] wl[123] wl[122] wl[121] wl[120] issahccarytrkdrv8x2
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccarytrkncn128x2
* View Name:    schematic
************************************************************************
.SUBCKT issahccarytrkncn128x2 bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn
+ sramvss trkbl wl[127] wl[126] wl[125] wl[124] wl[123] wl[122] wl[121] wl[120]
+ wl[119] wl[118] wl[117] wl[116] wl[115] wl[114] wl[113] wl[112] wl[111] wl[110]
+ wl[109] wl[108] wl[107] wl[106] wl[105] wl[104] wl[103] wl[102] wl[101] wl[100]
+ wl[99] wl[98] wl[97] wl[96] wl[95] wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88]
+ wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81] wl[80] wl[79] wl[78] wl[77] wl[76]
+ wl[75] wl[74] wl[73] wl[72] wl[71] wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64]
+ wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57] wl[56] wl[55] wl[54] wl[53] wl[52]
+ wl[51] wl[50] wl[49] wl[48] wl[47] wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40]
+ wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33] wl[32] wl[31] wl[30] wl[29] wl[28]
+ wl[27] wl[26] wl[25] wl[24] wl[23] wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16]
+ wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9] wl[8] wl[7] wl[6] wl[5] wl[4]
+ wl[3] wl[2] wl[1] wl[0]
*.PININFO bl_noconn[0]:I noconn[0]:I noconn[1]:I sramvcc:I sramvcc_noconn:I sramvss:I trkbl:B wl[127]:I wl[126]:I wl[125]:I wl[124]:I wl[123]:I wl[122]:I wl[121]:I wl[120]:I wl[119]:I wl[118]:I wl[117]:I wl[116]:I wl[115]:I
*.PININFO wl[114]:I wl[113]:I wl[112]:I wl[111]:I wl[110]:I wl[109]:I wl[108]:I wl[107]:I wl[106]:I wl[105]:I wl[104]:I wl[103]:I wl[102]:I wl[101]:I wl[100]:I wl[99]:I wl[98]:I wl[97]:I wl[96]:I wl[95]:I
*.PININFO wl[94]:I wl[93]:I wl[92]:I wl[91]:I wl[90]:I wl[89]:I wl[88]:I wl[87]:I wl[86]:I wl[85]:I wl[84]:I wl[83]:I wl[82]:I wl[81]:I wl[80]:I wl[79]:I wl[78]:I wl[77]:I wl[76]:I wl[75]:I
*.PININFO wl[74]:I wl[73]:I wl[72]:I wl[71]:I wl[70]:I wl[69]:I wl[68]:I wl[67]:I wl[66]:I wl[65]:I wl[64]:I wl[63]:I wl[62]:I wl[61]:I wl[60]:I wl[59]:I wl[58]:I wl[57]:I wl[56]:I wl[55]:I
*.PININFO wl[54]:I wl[53]:I wl[52]:I wl[51]:I wl[50]:I wl[49]:I wl[48]:I wl[47]:I wl[46]:I wl[45]:I wl[44]:I wl[43]:I wl[42]:I wl[41]:I wl[40]:I wl[39]:I wl[38]:I wl[37]:I wl[36]:I wl[35]:I
*.PININFO wl[34]:I wl[33]:I wl[32]:I wl[31]:I wl[30]:I wl[29]:I wl[28]:I wl[27]:I wl[26]:I wl[25]:I wl[24]:I wl[23]:I wl[22]:I wl[21]:I wl[20]:I wl[19]:I wl[18]:I wl[17]:I wl[16]:I wl[15]:I
*.PININFO wl[14]:I wl[13]:I wl[12]:I wl[11]:I wl[10]:I wl[9]:I wl[8]:I wl[7]:I wl[6]:I wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I
Xiary8x2[15] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[127] wl[126] wl[125] wl[124] wl[123] wl[122] wl[121] wl[120] issahccarytrkncn8x2
Xiary8x2[14] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[119] wl[118] wl[117] wl[116] wl[115] wl[114] wl[113] wl[112] issahccarytrkncn8x2
Xiary8x2[13] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[111] wl[110] wl[109] wl[108] wl[107] wl[106] wl[105] wl[104] issahccarytrkncn8x2
Xiary8x2[12] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[103] wl[102] wl[101] wl[100] wl[99] wl[98] wl[97] wl[96] issahccarytrkncn8x2
Xiary8x2[11] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[95] wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88] issahccarytrkncn8x2
Xiary8x2[10] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81] wl[80] issahccarytrkncn8x2
Xiary8x2[9] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[79] wl[78] wl[77] wl[76] wl[75] wl[74] wl[73] wl[72] issahccarytrkncn8x2
Xiary8x2[8] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[71] wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64] issahccarytrkncn8x2
Xiary8x2[7] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57] wl[56] issahccarytrkncn8x2
Xiary8x2[6] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[55] wl[54] wl[53] wl[52] wl[51] wl[50] wl[49] wl[48] issahccarytrkncn8x2
Xiary8x2[5] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[47] wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40] issahccarytrkncn8x2
Xiary8x2[4] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33] wl[32] issahccarytrkncn8x2
Xiary8x2[3] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[31] wl[30] wl[29] wl[28] wl[27] wl[26] wl[25] wl[24] issahccarytrkncn8x2
Xiary8x2[2] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[23] wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16] issahccarytrkncn8x2
Xiary8x2[1] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9] wl[8] issahccarytrkncn8x2
Xiary8x2[0] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0] issahccarytrkncn8x2
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccarytrkld128x2
* View Name:    schematic
************************************************************************
.SUBCKT issahccarytrkld128x2 bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn
+ sramvss trkbl wl[127] wl[126] wl[125] wl[124] wl[123] wl[122] wl[121] wl[120]
+ wl[119] wl[118] wl[117] wl[116] wl[115] wl[114] wl[113] wl[112] wl[111] wl[110]
+ wl[109] wl[108] wl[107] wl[106] wl[105] wl[104] wl[103] wl[102] wl[101] wl[100]
+ wl[99] wl[98] wl[97] wl[96] wl[95] wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88]
+ wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81] wl[80] wl[79] wl[78] wl[77] wl[76]
+ wl[75] wl[74] wl[73] wl[72] wl[71] wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64]
+ wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57] wl[56] wl[55] wl[54] wl[53] wl[52]
+ wl[51] wl[50] wl[49] wl[48] wl[47] wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40]
+ wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33] wl[32] wl[31] wl[30] wl[29] wl[28]
+ wl[27] wl[26] wl[25] wl[24] wl[23] wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16]
+ wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9] wl[8] wl[7] wl[6] wl[5] wl[4]
+ wl[3] wl[2] wl[1] wl[0]
*.PININFO bl_noconn[0]:I noconn[0]:I noconn[1]:I sramvcc:I sramvcc_noconn:I sramvss:I trkbl:B wl[127]:I wl[126]:I wl[125]:I wl[124]:I wl[123]:I wl[122]:I wl[121]:I wl[120]:I wl[119]:I wl[118]:I wl[117]:I wl[116]:I wl[115]:I
*.PININFO wl[114]:I wl[113]:I wl[112]:I wl[111]:I wl[110]:I wl[109]:I wl[108]:I wl[107]:I wl[106]:I wl[105]:I wl[104]:I wl[103]:I wl[102]:I wl[101]:I wl[100]:I wl[99]:I wl[98]:I wl[97]:I wl[96]:I wl[95]:I
*.PININFO wl[94]:I wl[93]:I wl[92]:I wl[91]:I wl[90]:I wl[89]:I wl[88]:I wl[87]:I wl[86]:I wl[85]:I wl[84]:I wl[83]:I wl[82]:I wl[81]:I wl[80]:I wl[79]:I wl[78]:I wl[77]:I wl[76]:I wl[75]:I
*.PININFO wl[74]:I wl[73]:I wl[72]:I wl[71]:I wl[70]:I wl[69]:I wl[68]:I wl[67]:I wl[66]:I wl[65]:I wl[64]:I wl[63]:I wl[62]:I wl[61]:I wl[60]:I wl[59]:I wl[58]:I wl[57]:I wl[56]:I wl[55]:I
*.PININFO wl[54]:I wl[53]:I wl[52]:I wl[51]:I wl[50]:I wl[49]:I wl[48]:I wl[47]:I wl[46]:I wl[45]:I wl[44]:I wl[43]:I wl[42]:I wl[41]:I wl[40]:I wl[39]:I wl[38]:I wl[37]:I wl[36]:I wl[35]:I
*.PININFO wl[34]:I wl[33]:I wl[32]:I wl[31]:I wl[30]:I wl[29]:I wl[28]:I wl[27]:I wl[26]:I wl[25]:I wl[24]:I wl[23]:I wl[22]:I wl[21]:I wl[20]:I wl[19]:I wl[18]:I wl[17]:I wl[16]:I wl[15]:I
*.PININFO wl[14]:I wl[13]:I wl[12]:I wl[11]:I wl[10]:I wl[9]:I wl[8]:I wl[7]:I wl[6]:I wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I
Xiary8x2[15] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[127] wl[126] wl[125] wl[124] wl[123] wl[122] wl[121] wl[120] issahccarytrkld8x2
Xiary8x2[14] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[119] wl[118] wl[117] wl[116] wl[115] wl[114] wl[113] wl[112] issahccarytrkld8x2
Xiary8x2[13] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[111] wl[110] wl[109] wl[108] wl[107] wl[106] wl[105] wl[104] issahccarytrkld8x2
Xiary8x2[12] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[103] wl[102] wl[101] wl[100] wl[99] wl[98] wl[97] wl[96] issahccarytrkld8x2
Xiary8x2[11] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[95] wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88] issahccarytrkld8x2
Xiary8x2[10] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81] wl[80] issahccarytrkld8x2
Xiary8x2[9] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[79] wl[78] wl[77] wl[76] wl[75] wl[74] wl[73] wl[72] issahccarytrkld8x2
Xiary8x2[8] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[71] wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64] issahccarytrkld8x2
Xiary8x2[7] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57] wl[56] issahccarytrkld8x2
Xiary8x2[6] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[55] wl[54] wl[53] wl[52] wl[51] wl[50] wl[49] wl[48] issahccarytrkld8x2
Xiary8x2[5] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[47] wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40] issahccarytrkld8x2
Xiary8x2[4] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33] wl[32] issahccarytrkld8x2
Xiary8x2[3] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[31] wl[30] wl[29] wl[28] wl[27] wl[26] wl[25] wl[24] issahccarytrkld8x2
Xiary8x2[2] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[23] wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16] issahccarytrkld8x2
Xiary8x2[1] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9] wl[8] issahccarytrkld8x2
Xiary8x2[0] bl_noconn[0] noconn[0] noconn[1] sramvcc sramvcc_noconn sramvss trkbl
+ wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0] issahccarytrkld8x2
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issax2dec256
* View Name:    schematic
************************************************************************
.SUBCKT issax2dec256 c6saveb_vccst c6savedec_vccst c6savet_vccst hinn[7] hinn[6]
+ hinn[5] hinn[4] hinn[3] hinn[2] hinn[1] hinn[0] midnn[7] midnn[6] midnn[5] midnn[4]
+ midnn[3] midnn[2] midnn[1] midnn[0] slpen vcc vssx wlb[127] wlb[126] wlb[125]
+ wlb[124] wlb[123] wlb[122] wlb[121] wlb[120] wlb[119] wlb[118] wlb[117] wlb[116]
+ wlb[115] wlb[114] wlb[113] wlb[112] wlb[111] wlb[110] wlb[109] wlb[108] wlb[107]
+ wlb[106] wlb[105] wlb[104] wlb[103] wlb[102] wlb[101] wlb[100] wlb[99] wlb[98]
+ wlb[97] wlb[96] wlb[95] wlb[94] wlb[93] wlb[92] wlb[91] wlb[90] wlb[89] wlb[88]
+ wlb[87] wlb[86] wlb[85] wlb[84] wlb[83] wlb[82] wlb[81] wlb[80] wlb[79] wlb[78]
+ wlb[77] wlb[76] wlb[75] wlb[74] wlb[73] wlb[72] wlb[71] wlb[70] wlb[69] wlb[68]
+ wlb[67] wlb[66] wlb[65] wlb[64] wlb[63] wlb[62] wlb[61] wlb[60] wlb[59] wlb[58]
+ wlb[57] wlb[56] wlb[55] wlb[54] wlb[53] wlb[52] wlb[51] wlb[50] wlb[49] wlb[48]
+ wlb[47] wlb[46] wlb[45] wlb[44] wlb[43] wlb[42] wlb[41] wlb[40] wlb[39] wlb[38]
+ wlb[37] wlb[36] wlb[35] wlb[34] wlb[33] wlb[32] wlb[31] wlb[30] wlb[29] wlb[28]
+ wlb[27] wlb[26] wlb[25] wlb[24] wlb[23] wlb[22] wlb[21] wlb[20] wlb[19] wlb[18]
+ wlb[17] wlb[16] wlb[15] wlb[14] wlb[13] wlb[12] wlb[11] wlb[10] wlb[9] wlb[8]
+ wlb[7] wlb[6] wlb[5] wlb[4] wlb[3] wlb[2] wlb[1] wlb[0] wlb[255] wlb[254] wlb[253]
+ wlb[252] wlb[251] wlb[250] wlb[249] wlb[248] wlb[247] wlb[246] wlb[245] wlb[244]
+ wlb[243] wlb[242] wlb[241] wlb[240] wlb[239] wlb[238] wlb[237] wlb[236] wlb[235]
+ wlb[234] wlb[233] wlb[232] wlb[231] wlb[230] wlb[229] wlb[228] wlb[227] wlb[226]
+ wlb[225] wlb[224] wlb[223] wlb[222] wlb[221] wlb[220] wlb[219] wlb[218] wlb[217]
+ wlb[216] wlb[215] wlb[214] wlb[213] wlb[212] wlb[211] wlb[210] wlb[209] wlb[208]
+ wlb[207] wlb[206] wlb[205] wlb[204] wlb[203] wlb[202] wlb[201] wlb[200] wlb[199]
+ wlb[198] wlb[197] wlb[196] wlb[195] wlb[194] wlb[193] wlb[192] wlb[191] wlb[190]
+ wlb[189] wlb[188] wlb[187] wlb[186] wlb[185] wlb[184] wlb[183] wlb[182] wlb[181]
+ wlb[180] wlb[179] wlb[178] wlb[177] wlb[176] wlb[175] wlb[174] wlb[173] wlb[172]
+ wlb[171] wlb[170] wlb[169] wlb[168] wlb[167] wlb[166] wlb[165] wlb[164] wlb[163]
+ wlb[162] wlb[161] wlb[160] wlb[159] wlb[158] wlb[157] wlb[156] wlb[155] wlb[154]
+ wlb[153] wlb[152] wlb[151] wlb[150] wlb[149] wlb[148] wlb[147] wlb[146] wlb[145]
+ wlb[144] wlb[143] wlb[142] wlb[141] wlb[140] wlb[139] wlb[138] wlb[137] wlb[136]
+ wlb[135] wlb[134] wlb[133] wlb[132] wlb[131] wlb[130] wlb[129] wlb[128] wle[3]
+ wle[2] wle[1] wle[0] wlered[1] wlered[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wlredb[1]
+ wlredb[0] wlredt[1] wlredt[0] wlt[127] wlt[126] wlt[125] wlt[124] wlt[123] wlt[122]
+ wlt[121] wlt[120] wlt[119] wlt[118] wlt[117] wlt[116] wlt[115] wlt[114] wlt[113]
+ wlt[112] wlt[111] wlt[110] wlt[109] wlt[108] wlt[107] wlt[106] wlt[105] wlt[104]
+ wlt[103] wlt[102] wlt[101] wlt[100] wlt[99] wlt[98] wlt[97] wlt[96] wlt[95] wlt[94]
+ wlt[93] wlt[92] wlt[91] wlt[90] wlt[89] wlt[88] wlt[87] wlt[86] wlt[85] wlt[84]
+ wlt[83] wlt[82] wlt[81] wlt[80] wlt[79] wlt[78] wlt[77] wlt[76] wlt[75] wlt[74]
+ wlt[73] wlt[72] wlt[71] wlt[70] wlt[69] wlt[68] wlt[67] wlt[66] wlt[65] wlt[64]
+ wlt[63] wlt[62] wlt[61] wlt[60] wlt[59] wlt[58] wlt[57] wlt[56] wlt[55] wlt[54]
+ wlt[53] wlt[52] wlt[51] wlt[50] wlt[49] wlt[48] wlt[47] wlt[46] wlt[45] wlt[44]
+ wlt[43] wlt[42] wlt[41] wlt[40] wlt[39] wlt[38] wlt[37] wlt[36] wlt[35] wlt[34]
+ wlt[33] wlt[32] wlt[31] wlt[30] wlt[29] wlt[28] wlt[27] wlt[26] wlt[25] wlt[24]
+ wlt[23] wlt[22] wlt[21] wlt[20] wlt[19] wlt[18] wlt[17] wlt[16] wlt[15] wlt[14]
+ wlt[13] wlt[12] wlt[11] wlt[10] wlt[9] wlt[8] wlt[7] wlt[6] wlt[5] wlt[4] wlt[3]
+ wlt[2] wlt[1] wlt[0] wlt[255] wlt[254] wlt[253] wlt[252] wlt[251] wlt[250] wlt[249]
+ wlt[248] wlt[247] wlt[246] wlt[245] wlt[244] wlt[243] wlt[242] wlt[241] wlt[240]
+ wlt[239] wlt[238] wlt[237] wlt[236] wlt[235] wlt[234] wlt[233] wlt[232] wlt[231]
+ wlt[230] wlt[229] wlt[228] wlt[227] wlt[226] wlt[225] wlt[224] wlt[223] wlt[222]
+ wlt[221] wlt[220] wlt[219] wlt[218] wlt[217] wlt[216] wlt[215] wlt[214] wlt[213]
+ wlt[212] wlt[211] wlt[210] wlt[209] wlt[208] wlt[207] wlt[206] wlt[205] wlt[204]
+ wlt[203] wlt[202] wlt[201] wlt[200] wlt[199] wlt[198] wlt[197] wlt[196] wlt[195]
+ wlt[194] wlt[193] wlt[192] wlt[191] wlt[190] wlt[189] wlt[188] wlt[187] wlt[186]
+ wlt[185] wlt[184] wlt[183] wlt[182] wlt[181] wlt[180] wlt[179] wlt[178] wlt[177]
+ wlt[176] wlt[175] wlt[174] wlt[173] wlt[172] wlt[171] wlt[170] wlt[169] wlt[168]
+ wlt[167] wlt[166] wlt[165] wlt[164] wlt[163] wlt[162] wlt[161] wlt[160] wlt[159]
+ wlt[158] wlt[157] wlt[156] wlt[155] wlt[154] wlt[153] wlt[152] wlt[151] wlt[150]
+ wlt[149] wlt[148] wlt[147] wlt[146] wlt[145] wlt[144] wlt[143] wlt[142] wlt[141]
+ wlt[140] wlt[139] wlt[138] wlt[137] wlt[136] wlt[135] wlt[134] wlt[133] wlt[132]
+ wlt[131] wlt[130] wlt[129] wlt[128]
*.PININFO c6saveb_vccst:I c6savedec_vccst:I c6savet_vccst:I hinn[7]:I hinn[6]:I hinn[5]:I hinn[4]:I hinn[3]:I hinn[2]:I hinn[1]:I hinn[0]:I midnn[7]:I midnn[6]:I midnn[5]:I midnn[4]:I midnn[3]:I midnn[2]:I midnn[1]:I midnn[0]:I slpen:I
*.PININFO vcc:I vssx:I wlb[127]:O wlb[126]:O wlb[125]:O wlb[124]:O wlb[123]:O wlb[122]:O wlb[121]:O wlb[120]:O wlb[119]:O wlb[118]:O wlb[117]:O wlb[116]:O wlb[115]:O wlb[114]:O wlb[113]:O wlb[112]:O wlb[111]:O wlb[110]:O
*.PININFO wlb[109]:O wlb[108]:O wlb[107]:O wlb[106]:O wlb[105]:O wlb[104]:O wlb[103]:O wlb[102]:O wlb[101]:O wlb[100]:O wlb[99]:O wlb[98]:O wlb[97]:O wlb[96]:O wlb[95]:O wlb[94]:O wlb[93]:O wlb[92]:O wlb[91]:O wlb[90]:O
*.PININFO wlb[89]:O wlb[88]:O wlb[87]:O wlb[86]:O wlb[85]:O wlb[84]:O wlb[83]:O wlb[82]:O wlb[81]:O wlb[80]:O wlb[79]:O wlb[78]:O wlb[77]:O wlb[76]:O wlb[75]:O wlb[74]:O wlb[73]:O wlb[72]:O wlb[71]:O wlb[70]:O
*.PININFO wlb[69]:O wlb[68]:O wlb[67]:O wlb[66]:O wlb[65]:O wlb[64]:O wlb[63]:O wlb[62]:O wlb[61]:O wlb[60]:O wlb[59]:O wlb[58]:O wlb[57]:O wlb[56]:O wlb[55]:O wlb[54]:O wlb[53]:O wlb[52]:O wlb[51]:O wlb[50]:O
*.PININFO wlb[49]:O wlb[48]:O wlb[47]:O wlb[46]:O wlb[45]:O wlb[44]:O wlb[43]:O wlb[42]:O wlb[41]:O wlb[40]:O wlb[39]:O wlb[38]:O wlb[37]:O wlb[36]:O wlb[35]:O wlb[34]:O wlb[33]:O wlb[32]:O wlb[31]:O wlb[30]:O
*.PININFO wlb[29]:O wlb[28]:O wlb[27]:O wlb[26]:O wlb[25]:O wlb[24]:O wlb[23]:O wlb[22]:O wlb[21]:O wlb[20]:O wlb[19]:O wlb[18]:O wlb[17]:O wlb[16]:O wlb[15]:O wlb[14]:O wlb[13]:O wlb[12]:O wlb[11]:O wlb[10]:O
*.PININFO wlb[9]:O wlb[8]:O wlb[7]:O wlb[6]:O wlb[5]:O wlb[4]:O wlb[3]:O wlb[2]:O wlb[1]:O wlb[0]:O wlb[255]:O wlb[254]:O wlb[253]:O wlb[252]:O wlb[251]:O wlb[250]:O wlb[249]:O wlb[248]:O wlb[247]:O wlb[246]:O
*.PININFO wlb[245]:O wlb[244]:O wlb[243]:O wlb[242]:O wlb[241]:O wlb[240]:O wlb[239]:O wlb[238]:O wlb[237]:O wlb[236]:O wlb[235]:O wlb[234]:O wlb[233]:O wlb[232]:O wlb[231]:O wlb[230]:O wlb[229]:O wlb[228]:O wlb[227]:O wlb[226]:O
*.PININFO wlb[225]:O wlb[224]:O wlb[223]:O wlb[222]:O wlb[221]:O wlb[220]:O wlb[219]:O wlb[218]:O wlb[217]:O wlb[216]:O wlb[215]:O wlb[214]:O wlb[213]:O wlb[212]:O wlb[211]:O wlb[210]:O wlb[209]:O wlb[208]:O wlb[207]:O wlb[206]:O
*.PININFO wlb[205]:O wlb[204]:O wlb[203]:O wlb[202]:O wlb[201]:O wlb[200]:O wlb[199]:O wlb[198]:O wlb[197]:O wlb[196]:O wlb[195]:O wlb[194]:O wlb[193]:O wlb[192]:O wlb[191]:O wlb[190]:O wlb[189]:O wlb[188]:O wlb[187]:O wlb[186]:O
*.PININFO wlb[185]:O wlb[184]:O wlb[183]:O wlb[182]:O wlb[181]:O wlb[180]:O wlb[179]:O wlb[178]:O wlb[177]:O wlb[176]:O wlb[175]:O wlb[174]:O wlb[173]:O wlb[172]:O wlb[171]:O wlb[170]:O wlb[169]:O wlb[168]:O wlb[167]:O wlb[166]:O
*.PININFO wlb[165]:O wlb[164]:O wlb[163]:O wlb[162]:O wlb[161]:O wlb[160]:O wlb[159]:O wlb[158]:O wlb[157]:O wlb[156]:O wlb[155]:O wlb[154]:O wlb[153]:O wlb[152]:O wlb[151]:O wlb[150]:O wlb[149]:O wlb[148]:O wlb[147]:O wlb[146]:O
*.PININFO wlb[145]:O wlb[144]:O wlb[143]:O wlb[142]:O wlb[141]:O wlb[140]:O wlb[139]:O wlb[138]:O wlb[137]:O wlb[136]:O wlb[135]:O wlb[134]:O wlb[133]:O wlb[132]:O wlb[131]:O wlb[130]:O wlb[129]:O wlb[128]:O wle[3]:I wle[2]:I
*.PININFO wle[1]:I wle[0]:I wlered[1]:I wlered[0]:I wllvlnn[2]:I wllvlnn[1]:I wllvlnn[0]:I wlredb[1]:O wlredb[0]:O wlredt[1]:O wlredt[0]:O wlt[127]:O wlt[126]:O wlt[125]:O wlt[124]:O wlt[123]:O wlt[122]:O wlt[121]:O wlt[120]:O wlt[119]:O
*.PININFO wlt[118]:O wlt[117]:O wlt[116]:O wlt[115]:O wlt[114]:O wlt[113]:O wlt[112]:O wlt[111]:O wlt[110]:O wlt[109]:O wlt[108]:O wlt[107]:O wlt[106]:O wlt[105]:O wlt[104]:O wlt[103]:O wlt[102]:O wlt[101]:O wlt[100]:O wlt[99]:O
*.PININFO wlt[98]:O wlt[97]:O wlt[96]:O wlt[95]:O wlt[94]:O wlt[93]:O wlt[92]:O wlt[91]:O wlt[90]:O wlt[89]:O wlt[88]:O wlt[87]:O wlt[86]:O wlt[85]:O wlt[84]:O wlt[83]:O wlt[82]:O wlt[81]:O wlt[80]:O wlt[79]:O
*.PININFO wlt[78]:O wlt[77]:O wlt[76]:O wlt[75]:O wlt[74]:O wlt[73]:O wlt[72]:O wlt[71]:O wlt[70]:O wlt[69]:O wlt[68]:O wlt[67]:O wlt[66]:O wlt[65]:O wlt[64]:O wlt[63]:O wlt[62]:O wlt[61]:O wlt[60]:O wlt[59]:O
*.PININFO wlt[58]:O wlt[57]:O wlt[56]:O wlt[55]:O wlt[54]:O wlt[53]:O wlt[52]:O wlt[51]:O wlt[50]:O wlt[49]:O wlt[48]:O wlt[47]:O wlt[46]:O wlt[45]:O wlt[44]:O wlt[43]:O wlt[42]:O wlt[41]:O wlt[40]:O wlt[39]:O
*.PININFO wlt[38]:O wlt[37]:O wlt[36]:O wlt[35]:O wlt[34]:O wlt[33]:O wlt[32]:O wlt[31]:O wlt[30]:O wlt[29]:O wlt[28]:O wlt[27]:O wlt[26]:O wlt[25]:O wlt[24]:O wlt[23]:O wlt[22]:O wlt[21]:O wlt[20]:O wlt[19]:O
*.PININFO wlt[18]:O wlt[17]:O wlt[16]:O wlt[15]:O wlt[14]:O wlt[13]:O wlt[12]:O wlt[11]:O wlt[10]:O wlt[9]:O wlt[8]:O wlt[7]:O wlt[6]:O wlt[5]:O wlt[4]:O wlt[3]:O wlt[2]:O wlt[1]:O wlt[0]:O wlt[255]:O
*.PININFO wlt[254]:O wlt[253]:O wlt[252]:O wlt[251]:O wlt[250]:O wlt[249]:O wlt[248]:O wlt[247]:O wlt[246]:O wlt[245]:O wlt[244]:O wlt[243]:O wlt[242]:O wlt[241]:O wlt[240]:O wlt[239]:O wlt[238]:O wlt[237]:O wlt[236]:O wlt[235]:O
*.PININFO wlt[234]:O wlt[233]:O wlt[232]:O wlt[231]:O wlt[230]:O wlt[229]:O wlt[228]:O wlt[227]:O wlt[226]:O wlt[225]:O wlt[224]:O wlt[223]:O wlt[222]:O wlt[221]:O wlt[220]:O wlt[219]:O wlt[218]:O wlt[217]:O wlt[216]:O wlt[215]:O
*.PININFO wlt[214]:O wlt[213]:O wlt[212]:O wlt[211]:O wlt[210]:O wlt[209]:O wlt[208]:O wlt[207]:O wlt[206]:O wlt[205]:O wlt[204]:O wlt[203]:O wlt[202]:O wlt[201]:O wlt[200]:O wlt[199]:O wlt[198]:O wlt[197]:O wlt[196]:O wlt[195]:O
*.PININFO wlt[194]:O wlt[193]:O wlt[192]:O wlt[191]:O wlt[190]:O wlt[189]:O wlt[188]:O wlt[187]:O wlt[186]:O wlt[185]:O wlt[184]:O wlt[183]:O wlt[182]:O wlt[181]:O wlt[180]:O wlt[179]:O wlt[178]:O wlt[177]:O wlt[176]:O wlt[175]:O
*.PININFO wlt[174]:O wlt[173]:O wlt[172]:O wlt[171]:O wlt[170]:O wlt[169]:O wlt[168]:O wlt[167]:O wlt[166]:O wlt[165]:O wlt[164]:O wlt[163]:O wlt[162]:O wlt[161]:O wlt[160]:O wlt[159]:O wlt[158]:O wlt[157]:O wlt[156]:O wlt[155]:O
*.PININFO wlt[154]:O wlt[153]:O wlt[152]:O wlt[151]:O wlt[150]:O wlt[149]:O wlt[148]:O wlt[147]:O wlt[146]:O wlt[145]:O wlt[144]:O wlt[143]:O wlt[142]:O wlt[141]:O wlt[140]:O wlt[139]:O wlt[138]:O wlt[137]:O wlt[136]:O wlt[135]:O
*.PININFO wlt[134]:O wlt[133]:O wlt[132]:O wlt[131]:O wlt[130]:O wlt[129]:O wlt[128]:O
Xdecvccpdn[1] c6savedec_vccst decvcct vssx issax2decvccpdn
Xdecvccpdn[0] c6savedec_vccst decvccb vssx issax2decvccpdn
Xdecdrv hinn[7] hinn[6] hinn[5] hinn[4] hinn[3] hinn[2] hinn[1] hinn[0] hi[7] hi[6]
+ hi[5] hi[4] hi[3] hi[2] hi[1] hi[0] midnn[7] midnn[6] midnn[5] midnn[4] midnn[3]
+ midnn[2] midnn[1] midnn[0] mid[7] mid[6] mid[5] mid[4] mid[3] mid[2] mid[1] mid[0]
+ slpen slpennn vcc vssx wle[3] wle[2] wle[1] wle[0] wlenn[3] wlenn[2] wlenn[1]
+ wlenn[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] wllvl[2] wllvl[1] wllvl[0] issaxdecdrivers
Xxdec128[0] c6saveb_vccst c6savet_vccst decvccb decvcct hi[3] hi[2] hi[1] hi[0]
+ mid[7] mid[6] mid[5] mid[4] mid[3] mid[2] mid[1] mid[0] slpenl slpennn vcc vssx
+ wlb[127] wlb[126] wlb[125] wlb[124] wlb[123] wlb[122] wlb[121] wlb[120] wlb[119]
+ wlb[118] wlb[117] wlb[116] wlb[115] wlb[114] wlb[113] wlb[112] wlb[111] wlb[110]
+ wlb[109] wlb[108] wlb[107] wlb[106] wlb[105] wlb[104] wlb[103] wlb[102] wlb[101]
+ wlb[100] wlb[99] wlb[98] wlb[97] wlb[96] wlb[95] wlb[94] wlb[93] wlb[92] wlb[91]
+ wlb[90] wlb[89] wlb[88] wlb[87] wlb[86] wlb[85] wlb[84] wlb[83] wlb[82] wlb[81]
+ wlb[80] wlb[79] wlb[78] wlb[77] wlb[76] wlb[75] wlb[74] wlb[73] wlb[72] wlb[71]
+ wlb[70] wlb[69] wlb[68] wlb[67] wlb[66] wlb[65] wlb[64] wlb[63] wlb[62] wlb[61]
+ wlb[60] wlb[59] wlb[58] wlb[57] wlb[56] wlb[55] wlb[54] wlb[53] wlb[52] wlb[51]
+ wlb[50] wlb[49] wlb[48] wlb[47] wlb[46] wlb[45] wlb[44] wlb[43] wlb[42] wlb[41]
+ wlb[40] wlb[39] wlb[38] wlb[37] wlb[36] wlb[35] wlb[34] wlb[33] wlb[32] wlb[31]
+ wlb[30] wlb[29] wlb[28] wlb[27] wlb[26] wlb[25] wlb[24] wlb[23] wlb[22] wlb[21]
+ wlb[20] wlb[19] wlb[18] wlb[17] wlb[16] wlb[15] wlb[14] wlb[13] wlb[12] wlb[11]
+ wlb[10] wlb[9] wlb[8] wlb[7] wlb[6] wlb[5] wlb[4] wlb[3] wlb[2] wlb[1] wlb[0]
+ wlenn[3] wlenn[2] wlenn[1] wlenn[0] wllvl[2] wllvl[1] wllvl[0] wllvllnn[2] wllvllnn[1]
+ wllvllnn[0] wlt[127] wlt[126] wlt[125] wlt[124] wlt[123] wlt[122] wlt[121] wlt[120]
+ wlt[119] wlt[118] wlt[117] wlt[116] wlt[115] wlt[114] wlt[113] wlt[112] wlt[111]
+ wlt[110] wlt[109] wlt[108] wlt[107] wlt[106] wlt[105] wlt[104] wlt[103] wlt[102]
+ wlt[101] wlt[100] wlt[99] wlt[98] wlt[97] wlt[96] wlt[95] wlt[94] wlt[93] wlt[92]
+ wlt[91] wlt[90] wlt[89] wlt[88] wlt[87] wlt[86] wlt[85] wlt[84] wlt[83] wlt[82]
+ wlt[81] wlt[80] wlt[79] wlt[78] wlt[77] wlt[76] wlt[75] wlt[74] wlt[73] wlt[72]
+ wlt[71] wlt[70] wlt[69] wlt[68] wlt[67] wlt[66] wlt[65] wlt[64] wlt[63] wlt[62]
+ wlt[61] wlt[60] wlt[59] wlt[58] wlt[57] wlt[56] wlt[55] wlt[54] wlt[53] wlt[52]
+ wlt[51] wlt[50] wlt[49] wlt[48] wlt[47] wlt[46] wlt[45] wlt[44] wlt[43] wlt[42]
+ wlt[41] wlt[40] wlt[39] wlt[38] wlt[37] wlt[36] wlt[35] wlt[34] wlt[33] wlt[32]
+ wlt[31] wlt[30] wlt[29] wlt[28] wlt[27] wlt[26] wlt[25] wlt[24] wlt[23] wlt[22]
+ wlt[21] wlt[20] wlt[19] wlt[18] wlt[17] wlt[16] wlt[15] wlt[14] wlt[13] wlt[12]
+ wlt[11] wlt[10] wlt[9] wlt[8] wlt[7] wlt[6] wlt[5] wlt[4] wlt[3] wlt[2] wlt[1]
+ wlt[0] issax2deci128
Xxdec128[1] c6saveb_vccst c6savet_vccst decvccb decvcct hi[7] hi[6] hi[5] hi[4]
+ mid[7] mid[6] mid[5] mid[4] mid[3] mid[2] mid[1] mid[0] slpenh slpennn vcc vssx
+ wlb[255] wlb[254] wlb[253] wlb[252] wlb[251] wlb[250] wlb[249] wlb[248] wlb[247]
+ wlb[246] wlb[245] wlb[244] wlb[243] wlb[242] wlb[241] wlb[240] wlb[239] wlb[238]
+ wlb[237] wlb[236] wlb[235] wlb[234] wlb[233] wlb[232] wlb[231] wlb[230] wlb[229]
+ wlb[228] wlb[227] wlb[226] wlb[225] wlb[224] wlb[223] wlb[222] wlb[221] wlb[220]
+ wlb[219] wlb[218] wlb[217] wlb[216] wlb[215] wlb[214] wlb[213] wlb[212] wlb[211]
+ wlb[210] wlb[209] wlb[208] wlb[207] wlb[206] wlb[205] wlb[204] wlb[203] wlb[202]
+ wlb[201] wlb[200] wlb[199] wlb[198] wlb[197] wlb[196] wlb[195] wlb[194] wlb[193]
+ wlb[192] wlb[191] wlb[190] wlb[189] wlb[188] wlb[187] wlb[186] wlb[185] wlb[184]
+ wlb[183] wlb[182] wlb[181] wlb[180] wlb[179] wlb[178] wlb[177] wlb[176] wlb[175]
+ wlb[174] wlb[173] wlb[172] wlb[171] wlb[170] wlb[169] wlb[168] wlb[167] wlb[166]
+ wlb[165] wlb[164] wlb[163] wlb[162] wlb[161] wlb[160] wlb[159] wlb[158] wlb[157]
+ wlb[156] wlb[155] wlb[154] wlb[153] wlb[152] wlb[151] wlb[150] wlb[149] wlb[148]
+ wlb[147] wlb[146] wlb[145] wlb[144] wlb[143] wlb[142] wlb[141] wlb[140] wlb[139]
+ wlb[138] wlb[137] wlb[136] wlb[135] wlb[134] wlb[133] wlb[132] wlb[131] wlb[130]
+ wlb[129] wlb[128] wlenn[3] wlenn[2] wlenn[1] wlenn[0] wllvl_fr[2] wllvl_fr[1]
+ wllvl_fr[0] wllvlnnh[2] wllvlnnh[1] wllvlnnh[0] wlt[255] wlt[254] wlt[253] wlt[252]
+ wlt[251] wlt[250] wlt[249] wlt[248] wlt[247] wlt[246] wlt[245] wlt[244] wlt[243]
+ wlt[242] wlt[241] wlt[240] wlt[239] wlt[238] wlt[237] wlt[236] wlt[235] wlt[234]
+ wlt[233] wlt[232] wlt[231] wlt[230] wlt[229] wlt[228] wlt[227] wlt[226] wlt[225]
+ wlt[224] wlt[223] wlt[222] wlt[221] wlt[220] wlt[219] wlt[218] wlt[217] wlt[216]
+ wlt[215] wlt[214] wlt[213] wlt[212] wlt[211] wlt[210] wlt[209] wlt[208] wlt[207]
+ wlt[206] wlt[205] wlt[204] wlt[203] wlt[202] wlt[201] wlt[200] wlt[199] wlt[198]
+ wlt[197] wlt[196] wlt[195] wlt[194] wlt[193] wlt[192] wlt[191] wlt[190] wlt[189]
+ wlt[188] wlt[187] wlt[186] wlt[185] wlt[184] wlt[183] wlt[182] wlt[181] wlt[180]
+ wlt[179] wlt[178] wlt[177] wlt[176] wlt[175] wlt[174] wlt[173] wlt[172] wlt[171]
+ wlt[170] wlt[169] wlt[168] wlt[167] wlt[166] wlt[165] wlt[164] wlt[163] wlt[162]
+ wlt[161] wlt[160] wlt[159] wlt[158] wlt[157] wlt[156] wlt[155] wlt[154] wlt[153]
+ wlt[152] wlt[151] wlt[150] wlt[149] wlt[148] wlt[147] wlt[146] wlt[145] wlt[144]
+ wlt[143] wlt[142] wlt[141] wlt[140] wlt[139] wlt[138] wlt[137] wlt[136] wlt[135]
+ wlt[134] wlt[133] wlt[132] wlt[131] wlt[130] wlt[129] wlt[128] issax2deci128
Xwllvlinv_fr[2] wllvlnn[2] wllvl_fr[2] vcc vssx inv_pcell_issax2dec256_13896219110017694169
Xwllvlinv_fr[1] wllvlnn[1] wllvl_fr[1] vcc vssx inv_pcell_issax2dec256_13896219110017694169
Xwllvlinv_fr[0] wllvlnn[0] wllvl_fr[0] vcc vssx inv_pcell_issax2dec256_13896219110017694169
Xxdecred c6saveb_vccst c6savet_vccst decvccb decvcct slpenl slpenl vcc vssx wlredb[1]
+ wlredb[0] wlered[1] wlered[0] wllvllnn[2] wllvllnn[1] wllvllnn[0] wllvllnn[2]
+ wllvllnn[1] wllvllnn[0] wlredt[1] wlredt[0] issax2decred
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccarytrk256x2
* View Name:    schematic
************************************************************************
.SUBCKT issahccarytrk256x2 sramvcc trkbl trkwl vssx wl[255] wl[254] wl[253] wl[252]
+ wl[251] wl[250] wl[249] wl[248] wl[247] wl[246] wl[245] wl[244] wl[243] wl[242]
+ wl[241] wl[240] wl[239] wl[238] wl[237] wl[236] wl[235] wl[234] wl[233] wl[232]
+ wl[231] wl[230] wl[229] wl[228] wl[227] wl[226] wl[225] wl[224] wl[223] wl[222]
+ wl[221] wl[220] wl[219] wl[218] wl[217] wl[216] wl[215] wl[214] wl[213] wl[212]
+ wl[211] wl[210] wl[209] wl[208] wl[207] wl[206] wl[205] wl[204] wl[203] wl[202]
+ wl[201] wl[200] wl[199] wl[198] wl[197] wl[196] wl[195] wl[194] wl[193] wl[192]
+ wl[191] wl[190] wl[189] wl[188] wl[187] wl[186] wl[185] wl[184] wl[183] wl[182]
+ wl[181] wl[180] wl[179] wl[178] wl[177] wl[176] wl[175] wl[174] wl[173] wl[172]
+ wl[171] wl[170] wl[169] wl[168] wl[167] wl[166] wl[165] wl[164] wl[163] wl[162]
+ wl[161] wl[160] wl[159] wl[158] wl[157] wl[156] wl[155] wl[154] wl[153] wl[152]
+ wl[151] wl[150] wl[149] wl[148] wl[147] wl[146] wl[145] wl[144] wl[143] wl[142]
+ wl[141] wl[140] wl[139] wl[138] wl[137] wl[136] wl[135] wl[134] wl[133] wl[132]
+ wl[131] wl[130] wl[129] wl[128] wl[127] wl[126] wl[125] wl[124] wl[123] wl[122]
+ wl[121] wl[120] wl[119] wl[118] wl[117] wl[116] wl[115] wl[114] wl[113] wl[112]
+ wl[111] wl[110] wl[109] wl[108] wl[107] wl[106] wl[105] wl[104] wl[103] wl[102]
+ wl[101] wl[100] wl[99] wl[98] wl[97] wl[96] wl[95] wl[94] wl[93] wl[92] wl[91]
+ wl[90] wl[89] wl[88] wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81] wl[80] wl[79]
+ wl[78] wl[77] wl[76] wl[75] wl[74] wl[73] wl[72] wl[71] wl[70] wl[69] wl[68] wl[67]
+ wl[66] wl[65] wl[64] wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57] wl[56] wl[55]
+ wl[54] wl[53] wl[52] wl[51] wl[50] wl[49] wl[48] wl[47] wl[46] wl[45] wl[44] wl[43]
+ wl[42] wl[41] wl[40] wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33] wl[32] wl[31]
+ wl[30] wl[29] wl[28] wl[27] wl[26] wl[25] wl[24] wl[23] wl[22] wl[21] wl[20] wl[19]
+ wl[18] wl[17] wl[16] wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9] wl[8] wl[7]
+ wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0] wlred[1] wlred[0]
*.PININFO sramvcc:I trkbl:B trkwl:I vssx:I wl[255]:I wl[254]:I wl[253]:I wl[252]:I wl[251]:I wl[250]:I wl[249]:I wl[248]:I wl[247]:I wl[246]:I wl[245]:I wl[244]:I wl[243]:I wl[242]:I wl[241]:I wl[240]:I
*.PININFO wl[239]:I wl[238]:I wl[237]:I wl[236]:I wl[235]:I wl[234]:I wl[233]:I wl[232]:I wl[231]:I wl[230]:I wl[229]:I wl[228]:I wl[227]:I wl[226]:I wl[225]:I wl[224]:I wl[223]:I wl[222]:I wl[221]:I wl[220]:I
*.PININFO wl[219]:I wl[218]:I wl[217]:I wl[216]:I wl[215]:I wl[214]:I wl[213]:I wl[212]:I wl[211]:I wl[210]:I wl[209]:I wl[208]:I wl[207]:I wl[206]:I wl[205]:I wl[204]:I wl[203]:I wl[202]:I wl[201]:I wl[200]:I
*.PININFO wl[199]:I wl[198]:I wl[197]:I wl[196]:I wl[195]:I wl[194]:I wl[193]:I wl[192]:I wl[191]:I wl[190]:I wl[189]:I wl[188]:I wl[187]:I wl[186]:I wl[185]:I wl[184]:I wl[183]:I wl[182]:I wl[181]:I wl[180]:I
*.PININFO wl[179]:I wl[178]:I wl[177]:I wl[176]:I wl[175]:I wl[174]:I wl[173]:I wl[172]:I wl[171]:I wl[170]:I wl[169]:I wl[168]:I wl[167]:I wl[166]:I wl[165]:I wl[164]:I wl[163]:I wl[162]:I wl[161]:I wl[160]:I
*.PININFO wl[159]:I wl[158]:I wl[157]:I wl[156]:I wl[155]:I wl[154]:I wl[153]:I wl[152]:I wl[151]:I wl[150]:I wl[149]:I wl[148]:I wl[147]:I wl[146]:I wl[145]:I wl[144]:I wl[143]:I wl[142]:I wl[141]:I wl[140]:I
*.PININFO wl[139]:I wl[138]:I wl[137]:I wl[136]:I wl[135]:I wl[134]:I wl[133]:I wl[132]:I wl[131]:I wl[130]:I wl[129]:I wl[128]:I wl[127]:I wl[126]:I wl[125]:I wl[124]:I wl[123]:I wl[122]:I wl[121]:I wl[120]:I
*.PININFO wl[119]:I wl[118]:I wl[117]:I wl[116]:I wl[115]:I wl[114]:I wl[113]:I wl[112]:I wl[111]:I wl[110]:I wl[109]:I wl[108]:I wl[107]:I wl[106]:I wl[105]:I wl[104]:I wl[103]:I wl[102]:I wl[101]:I wl[100]:I
*.PININFO wl[99]:I wl[98]:I wl[97]:I wl[96]:I wl[95]:I wl[94]:I wl[93]:I wl[92]:I wl[91]:I wl[90]:I wl[89]:I wl[88]:I wl[87]:I wl[86]:I wl[85]:I wl[84]:I wl[83]:I wl[82]:I wl[81]:I wl[80]:I
*.PININFO wl[79]:I wl[78]:I wl[77]:I wl[76]:I wl[75]:I wl[74]:I wl[73]:I wl[72]:I wl[71]:I wl[70]:I wl[69]:I wl[68]:I wl[67]:I wl[66]:I wl[65]:I wl[64]:I wl[63]:I wl[62]:I wl[61]:I wl[60]:I
*.PININFO wl[59]:I wl[58]:I wl[57]:I wl[56]:I wl[55]:I wl[54]:I wl[53]:I wl[52]:I wl[51]:I wl[50]:I wl[49]:I wl[48]:I wl[47]:I wl[46]:I wl[45]:I wl[44]:I wl[43]:I wl[42]:I wl[41]:I wl[40]:I
*.PININFO wl[39]:I wl[38]:I wl[37]:I wl[36]:I wl[35]:I wl[34]:I wl[33]:I wl[32]:I wl[31]:I wl[30]:I wl[29]:I wl[28]:I wl[27]:I wl[26]:I wl[25]:I wl[24]:I wl[23]:I wl[22]:I wl[21]:I wl[20]:I
*.PININFO wl[19]:I wl[18]:I wl[17]:I wl[16]:I wl[15]:I wl[14]:I wl[13]:I wl[12]:I wl[11]:I wl[10]:I wl[9]:I wl[8]:I wl[7]:I wl[6]:I wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I
*.PININFO wlred[1]:I wlred[0]:I
Xary128x2lf net1 bl[0] bl[1] sramvcc sramvcc_noconn vssx trkbl wl[255] wl[254] wl[253]
+ wl[252] wl[251] wl[250] wl[249] wl[248] wl[247] wl[246] wl[245] wl[244] wl[243]
+ wl[242] wl[241] wl[240] wl[239] wl[238] wl[237] wl[236] wl[235] wl[234] wl[233]
+ wl[232] wl[231] wl[230] wl[229] wl[228] wl[227] wl[226] wl[225] wl[224] wl[223]
+ wl[222] wl[221] wl[220] wl[219] wl[218] wl[217] wl[216] wl[215] wl[214] wl[213]
+ wl[212] wl[211] wl[210] wl[209] wl[208] wl[207] wl[206] wl[205] wl[204] wl[203]
+ wl[202] wl[201] wl[200] wl[199] wl[198] wl[197] wl[196] wl[195] wl[194] wl[193]
+ wl[192] wl[191] wl[190] wl[189] wl[188] wl[187] wl[186] wl[185] wl[184] wl[183]
+ wl[182] wl[181] wl[180] wl[179] wl[178] wl[177] wl[176] wl[175] wl[174] wl[173]
+ wl[172] wl[171] wl[170] wl[169] wl[168] wl[167] wl[166] wl[165] wl[164] wl[163]
+ wl[162] wl[161] wl[160] wl[159] wl[158] wl[157] wl[156] wl[155] wl[154] wl[153]
+ wl[152] wl[151] wl[150] wl[149] wl[148] wl[147] wl[146] wl[145] wl[144] wl[143]
+ wl[142] wl[141] wl[140] wl[139] wl[138] wl[137] wl[136] wl[135] wl[134] wl[133]
+ wl[132] wl[131] wl[130] wl[129] wl[128] issahccarytrkld128x2
Xredbits2x2l net1 bl[0] bl[1] sramvcc sramvcc_noconn vssx trkbl wlred[1] wlred[0] issahccarytrkred2x2
Xary128x2rt net1 bl[0] bl[1] sramvcc sramvcc_noconn vssx trkbl trkwl wl[127] wl[126]
+ wl[125] wl[124] wl[123] wl[122] wl[121] wl[120] wl[119] wl[118] wl[117] wl[116]
+ wl[115] wl[114] wl[113] wl[112] wl[111] wl[110] wl[109] wl[108] wl[107] wl[106]
+ wl[105] wl[104] wl[103] wl[102] wl[101] wl[100] wl[99] wl[98] wl[97] wl[96] wl[95]
+ wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88] wl[87] wl[86] wl[85] wl[84] wl[83]
+ wl[82] wl[81] wl[80] wl[79] wl[78] wl[77] wl[76] wl[75] wl[74] wl[73] wl[72] wl[71]
+ wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64] wl[63] wl[62] wl[61] wl[60] wl[59]
+ wl[58] wl[57] wl[56] wl[55] wl[54] wl[53] wl[52] wl[51] wl[50] wl[49] wl[48] wl[47]
+ wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40] wl[39] wl[38] wl[37] wl[36] wl[35]
+ wl[34] wl[33] wl[32] wl[31] wl[30] wl[29] wl[28] wl[27] wl[26] wl[25] wl[24] wl[23]
+ wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16] wl[15] wl[14] wl[13] wl[12] wl[11]
+ wl[10] wl[9] wl[8] wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0] issahccarytrkdrvld128x2
Xbitedge_rt bl[1] bl[0] sramvcc sramvcc_noconn vssx x78hcc5edg1x2
Xbitedge_lf bl[1] bl[0] sramvcc sramvcc_noconn vssx x78hcc5edg1x2
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccarytrkncn256x2
* View Name:    schematic
************************************************************************
.SUBCKT issahccarytrkncn256x2 sramvcc vssx wl[127] wl[126] wl[125] wl[124] wl[123]
+ wl[122] wl[121] wl[120] wl[119] wl[118] wl[117] wl[116] wl[115] wl[114] wl[113]
+ wl[112] wl[111] wl[110] wl[109] wl[108] wl[107] wl[106] wl[105] wl[104] wl[103]
+ wl[102] wl[101] wl[100] wl[99] wl[98] wl[97] wl[96] wl[95] wl[94] wl[93] wl[92]
+ wl[91] wl[90] wl[89] wl[88] wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81] wl[80]
+ wl[79] wl[78] wl[77] wl[76] wl[75] wl[74] wl[73] wl[72] wl[71] wl[70] wl[69] wl[68]
+ wl[67] wl[66] wl[65] wl[64] wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57] wl[56]
+ wl[55] wl[54] wl[53] wl[52] wl[51] wl[50] wl[49] wl[48] wl[47] wl[46] wl[45] wl[44]
+ wl[43] wl[42] wl[41] wl[40] wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33] wl[32]
+ wl[31] wl[30] wl[29] wl[28] wl[27] wl[26] wl[25] wl[24] wl[23] wl[22] wl[21] wl[20]
+ wl[19] wl[18] wl[17] wl[16] wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9] wl[8]
+ wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0] wl[255] wl[254] wl[253] wl[252]
+ wl[251] wl[250] wl[249] wl[248] wl[247] wl[246] wl[245] wl[244] wl[243] wl[242]
+ wl[241] wl[240] wl[239] wl[238] wl[237] wl[236] wl[235] wl[234] wl[233] wl[232]
+ wl[231] wl[230] wl[229] wl[228] wl[227] wl[226] wl[225] wl[224] wl[223] wl[222]
+ wl[221] wl[220] wl[219] wl[218] wl[217] wl[216] wl[215] wl[214] wl[213] wl[212]
+ wl[211] wl[210] wl[209] wl[208] wl[207] wl[206] wl[205] wl[204] wl[203] wl[202]
+ wl[201] wl[200] wl[199] wl[198] wl[197] wl[196] wl[195] wl[194] wl[193] wl[192]
+ wl[191] wl[190] wl[189] wl[188] wl[187] wl[186] wl[185] wl[184] wl[183] wl[182]
+ wl[181] wl[180] wl[179] wl[178] wl[177] wl[176] wl[175] wl[174] wl[173] wl[172]
+ wl[171] wl[170] wl[169] wl[168] wl[167] wl[166] wl[165] wl[164] wl[163] wl[162]
+ wl[161] wl[160] wl[159] wl[158] wl[157] wl[156] wl[155] wl[154] wl[153] wl[152]
+ wl[151] wl[150] wl[149] wl[148] wl[147] wl[146] wl[145] wl[144] wl[143] wl[142]
+ wl[141] wl[140] wl[139] wl[138] wl[137] wl[136] wl[135] wl[134] wl[133] wl[132]
+ wl[131] wl[130] wl[129] wl[128] wlred[1] wlred[0]
*.PININFO sramvcc:I vssx:I wl[127]:I wl[126]:I wl[125]:I wl[124]:I wl[123]:I wl[122]:I wl[121]:I wl[120]:I wl[119]:I wl[118]:I wl[117]:I wl[116]:I wl[115]:I wl[114]:I wl[113]:I wl[112]:I wl[111]:I wl[110]:I
*.PININFO wl[109]:I wl[108]:I wl[107]:I wl[106]:I wl[105]:I wl[104]:I wl[103]:I wl[102]:I wl[101]:I wl[100]:I wl[99]:I wl[98]:I wl[97]:I wl[96]:I wl[95]:I wl[94]:I wl[93]:I wl[92]:I wl[91]:I wl[90]:I
*.PININFO wl[89]:I wl[88]:I wl[87]:I wl[86]:I wl[85]:I wl[84]:I wl[83]:I wl[82]:I wl[81]:I wl[80]:I wl[79]:I wl[78]:I wl[77]:I wl[76]:I wl[75]:I wl[74]:I wl[73]:I wl[72]:I wl[71]:I wl[70]:I
*.PININFO wl[69]:I wl[68]:I wl[67]:I wl[66]:I wl[65]:I wl[64]:I wl[63]:I wl[62]:I wl[61]:I wl[60]:I wl[59]:I wl[58]:I wl[57]:I wl[56]:I wl[55]:I wl[54]:I wl[53]:I wl[52]:I wl[51]:I wl[50]:I
*.PININFO wl[49]:I wl[48]:I wl[47]:I wl[46]:I wl[45]:I wl[44]:I wl[43]:I wl[42]:I wl[41]:I wl[40]:I wl[39]:I wl[38]:I wl[37]:I wl[36]:I wl[35]:I wl[34]:I wl[33]:I wl[32]:I wl[31]:I wl[30]:I
*.PININFO wl[29]:I wl[28]:I wl[27]:I wl[26]:I wl[25]:I wl[24]:I wl[23]:I wl[22]:I wl[21]:I wl[20]:I wl[19]:I wl[18]:I wl[17]:I wl[16]:I wl[15]:I wl[14]:I wl[13]:I wl[12]:I wl[11]:I wl[10]:I
*.PININFO wl[9]:I wl[8]:I wl[7]:I wl[6]:I wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I wl[255]:I wl[254]:I wl[253]:I wl[252]:I wl[251]:I wl[250]:I wl[249]:I wl[248]:I wl[247]:I wl[246]:I
*.PININFO wl[245]:I wl[244]:I wl[243]:I wl[242]:I wl[241]:I wl[240]:I wl[239]:I wl[238]:I wl[237]:I wl[236]:I wl[235]:I wl[234]:I wl[233]:I wl[232]:I wl[231]:I wl[230]:I wl[229]:I wl[228]:I wl[227]:I wl[226]:I
*.PININFO wl[225]:I wl[224]:I wl[223]:I wl[222]:I wl[221]:I wl[220]:I wl[219]:I wl[218]:I wl[217]:I wl[216]:I wl[215]:I wl[214]:I wl[213]:I wl[212]:I wl[211]:I wl[210]:I wl[209]:I wl[208]:I wl[207]:I wl[206]:I
*.PININFO wl[205]:I wl[204]:I wl[203]:I wl[202]:I wl[201]:I wl[200]:I wl[199]:I wl[198]:I wl[197]:I wl[196]:I wl[195]:I wl[194]:I wl[193]:I wl[192]:I wl[191]:I wl[190]:I wl[189]:I wl[188]:I wl[187]:I wl[186]:I
*.PININFO wl[185]:I wl[184]:I wl[183]:I wl[182]:I wl[181]:I wl[180]:I wl[179]:I wl[178]:I wl[177]:I wl[176]:I wl[175]:I wl[174]:I wl[173]:I wl[172]:I wl[171]:I wl[170]:I wl[169]:I wl[168]:I wl[167]:I wl[166]:I
*.PININFO wl[165]:I wl[164]:I wl[163]:I wl[162]:I wl[161]:I wl[160]:I wl[159]:I wl[158]:I wl[157]:I wl[156]:I wl[155]:I wl[154]:I wl[153]:I wl[152]:I wl[151]:I wl[150]:I wl[149]:I wl[148]:I wl[147]:I wl[146]:I
*.PININFO wl[145]:I wl[144]:I wl[143]:I wl[142]:I wl[141]:I wl[140]:I wl[139]:I wl[138]:I wl[137]:I wl[136]:I wl[135]:I wl[134]:I wl[133]:I wl[132]:I wl[131]:I wl[130]:I wl[129]:I wl[128]:I wlred[1]:I wlred[0]:I
Xbitedge_lf bl[1] bl[0] sramvcc sramvcc_noconn vssx x78hcc5edg1x2
Xbitedge_rt bl[1] bl[0] sramvcc sramvcc_noconn vssx x78hcc5edg1x2
Xredbits2x2l net1 bl[0] bl[1] sramvcc sramvcc_noconn vssx net2 wlred[1] wlred[0] issahccarytrkrdncn2x2
Xary128x2lf net1 bl[0] bl[1] sramvcc sramvcc_noconn vssx net2 wl[255] wl[254] wl[253]
+ wl[252] wl[251] wl[250] wl[249] wl[248] wl[247] wl[246] wl[245] wl[244] wl[243]
+ wl[242] wl[241] wl[240] wl[239] wl[238] wl[237] wl[236] wl[235] wl[234] wl[233]
+ wl[232] wl[231] wl[230] wl[229] wl[228] wl[227] wl[226] wl[225] wl[224] wl[223]
+ wl[222] wl[221] wl[220] wl[219] wl[218] wl[217] wl[216] wl[215] wl[214] wl[213]
+ wl[212] wl[211] wl[210] wl[209] wl[208] wl[207] wl[206] wl[205] wl[204] wl[203]
+ wl[202] wl[201] wl[200] wl[199] wl[198] wl[197] wl[196] wl[195] wl[194] wl[193]
+ wl[192] wl[191] wl[190] wl[189] wl[188] wl[187] wl[186] wl[185] wl[184] wl[183]
+ wl[182] wl[181] wl[180] wl[179] wl[178] wl[177] wl[176] wl[175] wl[174] wl[173]
+ wl[172] wl[171] wl[170] wl[169] wl[168] wl[167] wl[166] wl[165] wl[164] wl[163]
+ wl[162] wl[161] wl[160] wl[159] wl[158] wl[157] wl[156] wl[155] wl[154] wl[153]
+ wl[152] wl[151] wl[150] wl[149] wl[148] wl[147] wl[146] wl[145] wl[144] wl[143]
+ wl[142] wl[141] wl[140] wl[139] wl[138] wl[137] wl[136] wl[135] wl[134] wl[133]
+ wl[132] wl[131] wl[130] wl[129] wl[128] issahccarytrkncn128x2
Xary128x2rt net1 bl[0] bl[1] sramvcc sramvcc_noconn vssx net2 wl[127] wl[126] wl[125]
+ wl[124] wl[123] wl[122] wl[121] wl[120] wl[119] wl[118] wl[117] wl[116] wl[115]
+ wl[114] wl[113] wl[112] wl[111] wl[110] wl[109] wl[108] wl[107] wl[106] wl[105]
+ wl[104] wl[103] wl[102] wl[101] wl[100] wl[99] wl[98] wl[97] wl[96] wl[95] wl[94]
+ wl[93] wl[92] wl[91] wl[90] wl[89] wl[88] wl[87] wl[86] wl[85] wl[84] wl[83] wl[82]
+ wl[81] wl[80] wl[79] wl[78] wl[77] wl[76] wl[75] wl[74] wl[73] wl[72] wl[71] wl[70]
+ wl[69] wl[68] wl[67] wl[66] wl[65] wl[64] wl[63] wl[62] wl[61] wl[60] wl[59] wl[58]
+ wl[57] wl[56] wl[55] wl[54] wl[53] wl[52] wl[51] wl[50] wl[49] wl[48] wl[47] wl[46]
+ wl[45] wl[44] wl[43] wl[42] wl[41] wl[40] wl[39] wl[38] wl[37] wl[36] wl[35] wl[34]
+ wl[33] wl[32] wl[31] wl[30] wl[29] wl[28] wl[27] wl[26] wl[25] wl[24] wl[23] wl[22]
+ wl[21] wl[20] wl[19] wl[18] wl[17] wl[16] wl[15] wl[14] wl[13] wl[12] wl[11] wl[10]
+ wl[9] wl[8] wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0] issahccarytrkncn128x2
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccaryi128x4
* View Name:    schematic
************************************************************************
.SUBCKT issahccaryi128x4 bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0]
+ sramvcc sramvss wl[127] wl[126] wl[125] wl[124] wl[123] wl[122] wl[121] wl[120]
+ wl[119] wl[118] wl[117] wl[116] wl[115] wl[114] wl[113] wl[112] wl[111] wl[110]
+ wl[109] wl[108] wl[107] wl[106] wl[105] wl[104] wl[103] wl[102] wl[101] wl[100]
+ wl[99] wl[98] wl[97] wl[96] wl[95] wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88]
+ wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81] wl[80] wl[79] wl[78] wl[77] wl[76]
+ wl[75] wl[74] wl[73] wl[72] wl[71] wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64]
+ wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57] wl[56] wl[55] wl[54] wl[53] wl[52]
+ wl[51] wl[50] wl[49] wl[48] wl[47] wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40]
+ wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33] wl[32] wl[31] wl[30] wl[29] wl[28]
+ wl[27] wl[26] wl[25] wl[24] wl[23] wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16]
+ wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9] wl[8] wl[7] wl[6] wl[5] wl[4]
+ wl[3] wl[2] wl[1] wl[0]
*.PININFO bl[3]:B bl[2]:B bl[1]:B bl[0]:B bl_b[3]:B bl_b[2]:B bl_b[1]:B bl_b[0]:B sramvcc:I sramvss:I wl[127]:I wl[126]:I wl[125]:I wl[124]:I wl[123]:I wl[122]:I wl[121]:I wl[120]:I wl[119]:I wl[118]:I
*.PININFO wl[117]:I wl[116]:I wl[115]:I wl[114]:I wl[113]:I wl[112]:I wl[111]:I wl[110]:I wl[109]:I wl[108]:I wl[107]:I wl[106]:I wl[105]:I wl[104]:I wl[103]:I wl[102]:I wl[101]:I wl[100]:I wl[99]:I wl[98]:I
*.PININFO wl[97]:I wl[96]:I wl[95]:I wl[94]:I wl[93]:I wl[92]:I wl[91]:I wl[90]:I wl[89]:I wl[88]:I wl[87]:I wl[86]:I wl[85]:I wl[84]:I wl[83]:I wl[82]:I wl[81]:I wl[80]:I wl[79]:I wl[78]:I
*.PININFO wl[77]:I wl[76]:I wl[75]:I wl[74]:I wl[73]:I wl[72]:I wl[71]:I wl[70]:I wl[69]:I wl[68]:I wl[67]:I wl[66]:I wl[65]:I wl[64]:I wl[63]:I wl[62]:I wl[61]:I wl[60]:I wl[59]:I wl[58]:I
*.PININFO wl[57]:I wl[56]:I wl[55]:I wl[54]:I wl[53]:I wl[52]:I wl[51]:I wl[50]:I wl[49]:I wl[48]:I wl[47]:I wl[46]:I wl[45]:I wl[44]:I wl[43]:I wl[42]:I wl[41]:I wl[40]:I wl[39]:I wl[38]:I
*.PININFO wl[37]:I wl[36]:I wl[35]:I wl[34]:I wl[33]:I wl[32]:I wl[31]:I wl[30]:I wl[29]:I wl[28]:I wl[27]:I wl[26]:I wl[25]:I wl[24]:I wl[23]:I wl[22]:I wl[21]:I wl[20]:I wl[19]:I wl[18]:I
*.PININFO wl[17]:I wl[16]:I wl[15]:I wl[14]:I wl[13]:I wl[12]:I wl[11]:I wl[10]:I wl[9]:I wl[8]:I wl[7]:I wl[6]:I wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I
Xiary8x4[15] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[127] wl[126] wl[125] wl[124] wl[123] wl[122] wl[121] wl[120] issahccary8x4
Xiary8x4[14] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[119] wl[118] wl[117] wl[116] wl[115] wl[114] wl[113] wl[112] issahccary8x4
Xiary8x4[13] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[111] wl[110] wl[109] wl[108] wl[107] wl[106] wl[105] wl[104] issahccary8x4
Xiary8x4[12] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[103] wl[102] wl[101] wl[100] wl[99] wl[98] wl[97] wl[96] issahccary8x4
Xiary8x4[11] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[95] wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88] issahccary8x4
Xiary8x4[10] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81] wl[80] issahccary8x4
Xiary8x4[9] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[79] wl[78] wl[77] wl[76] wl[75] wl[74] wl[73] wl[72] issahccary8x4
Xiary8x4[8] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[71] wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64] issahccary8x4
Xiary8x4[7] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57] wl[56] issahccary8x4
Xiary8x4[6] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[55] wl[54] wl[53] wl[52] wl[51] wl[50] wl[49] wl[48] issahccary8x4
Xiary8x4[5] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[47] wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40] issahccary8x4
Xiary8x4[4] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33] wl[32] issahccary8x4
Xiary8x4[3] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[31] wl[30] wl[29] wl[28] wl[27] wl[26] wl[25] wl[24] issahccary8x4
Xiary8x4[2] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[23] wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16] issahccary8x4
Xiary8x4[1] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9] wl[8] issahccary8x4
Xiary8x4[0] bl[3] bl[2] bl[1] bl[0] bl_b[3] bl_b[2] bl_b[1] bl_b[0] sramvcc sramvss
+ wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0] issahccary8x4
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahcctrk256slc
* View Name:    schematic
************************************************************************
.SUBCKT issahcctrk256slc clkwr2lnn fine_kick[3] fine_kick[2] fine_kick[1] fine_kick[0]
+ nblkick rdwl rdwlclkmx rdwlpw[3] rdwlpw[2] rdwlpw[1] rdwlpw[0] sramvcc synckick
+ syncrd syncwr trkwllvlnn[2] trkwllvlnn[1] trkwllvlnn[0] vcc vssx wl[255] wl[254]
+ wl[253] wl[252] wl[251] wl[250] wl[249] wl[248] wl[247] wl[246] wl[245] wl[244]
+ wl[243] wl[242] wl[241] wl[240] wl[239] wl[238] wl[237] wl[236] wl[235] wl[234]
+ wl[233] wl[232] wl[231] wl[230] wl[229] wl[228] wl[227] wl[226] wl[225] wl[224]
+ wl[223] wl[222] wl[221] wl[220] wl[219] wl[218] wl[217] wl[216] wl[215] wl[214]
+ wl[213] wl[212] wl[211] wl[210] wl[209] wl[208] wl[207] wl[206] wl[205] wl[204]
+ wl[203] wl[202] wl[201] wl[200] wl[199] wl[198] wl[197] wl[196] wl[195] wl[194]
+ wl[193] wl[192] wl[191] wl[190] wl[189] wl[188] wl[187] wl[186] wl[185] wl[184]
+ wl[183] wl[182] wl[181] wl[180] wl[179] wl[178] wl[177] wl[176] wl[175] wl[174]
+ wl[173] wl[172] wl[171] wl[170] wl[169] wl[168] wl[167] wl[166] wl[165] wl[164]
+ wl[163] wl[162] wl[161] wl[160] wl[159] wl[158] wl[157] wl[156] wl[155] wl[154]
+ wl[153] wl[152] wl[151] wl[150] wl[149] wl[148] wl[147] wl[146] wl[145] wl[144]
+ wl[143] wl[142] wl[141] wl[140] wl[139] wl[138] wl[137] wl[136] wl[135] wl[134]
+ wl[133] wl[132] wl[131] wl[130] wl[129] wl[128] wl[127] wl[126] wl[125] wl[124]
+ wl[123] wl[122] wl[121] wl[120] wl[119] wl[118] wl[117] wl[116] wl[115] wl[114]
+ wl[113] wl[112] wl[111] wl[110] wl[109] wl[108] wl[107] wl[106] wl[105] wl[104]
+ wl[103] wl[102] wl[101] wl[100] wl[99] wl[98] wl[97] wl[96] wl[95] wl[94] wl[93]
+ wl[92] wl[91] wl[90] wl[89] wl[88] wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81]
+ wl[80] wl[79] wl[78] wl[77] wl[76] wl[75] wl[74] wl[73] wl[72] wl[71] wl[70] wl[69]
+ wl[68] wl[67] wl[66] wl[65] wl[64] wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57]
+ wl[56] wl[55] wl[54] wl[53] wl[52] wl[51] wl[50] wl[49] wl[48] wl[47] wl[46] wl[45]
+ wl[44] wl[43] wl[42] wl[41] wl[40] wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33]
+ wl[32] wl[31] wl[30] wl[29] wl[28] wl[27] wl[26] wl[25] wl[24] wl[23] wl[22] wl[21]
+ wl[20] wl[19] wl[18] wl[17] wl[16] wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9]
+ wl[8] wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0] wlred[1] wlred[0] wrwl wrwlclkmx
+ wrwlpw[1] wrwlpw[0]
*.PININFO clkwr2lnn:I fine_kick[3]:I fine_kick[2]:I fine_kick[1]:I fine_kick[0]:I nblkick:O rdwl:I rdwlclkmx:O rdwlpw[3]:I rdwlpw[2]:I rdwlpw[1]:I rdwlpw[0]:I sramvcc:I synckick:I syncrd:I syncwr:I trkwllvlnn[2]:I trkwllvlnn[1]:I trkwllvlnn[0]:I vcc:I
*.PININFO vssx:I wl[255]:I wl[254]:I wl[253]:I wl[252]:I wl[251]:I wl[250]:I wl[249]:I wl[248]:I wl[247]:I wl[246]:I wl[245]:I wl[244]:I wl[243]:I wl[242]:I wl[241]:I wl[240]:I wl[239]:I wl[238]:I wl[237]:I
*.PININFO wl[236]:I wl[235]:I wl[234]:I wl[233]:I wl[232]:I wl[231]:I wl[230]:I wl[229]:I wl[228]:I wl[227]:I wl[226]:I wl[225]:I wl[224]:I wl[223]:I wl[222]:I wl[221]:I wl[220]:I wl[219]:I wl[218]:I wl[217]:I
*.PININFO wl[216]:I wl[215]:I wl[214]:I wl[213]:I wl[212]:I wl[211]:I wl[210]:I wl[209]:I wl[208]:I wl[207]:I wl[206]:I wl[205]:I wl[204]:I wl[203]:I wl[202]:I wl[201]:I wl[200]:I wl[199]:I wl[198]:I wl[197]:I
*.PININFO wl[196]:I wl[195]:I wl[194]:I wl[193]:I wl[192]:I wl[191]:I wl[190]:I wl[189]:I wl[188]:I wl[187]:I wl[186]:I wl[185]:I wl[184]:I wl[183]:I wl[182]:I wl[181]:I wl[180]:I wl[179]:I wl[178]:I wl[177]:I
*.PININFO wl[176]:I wl[175]:I wl[174]:I wl[173]:I wl[172]:I wl[171]:I wl[170]:I wl[169]:I wl[168]:I wl[167]:I wl[166]:I wl[165]:I wl[164]:I wl[163]:I wl[162]:I wl[161]:I wl[160]:I wl[159]:I wl[158]:I wl[157]:I
*.PININFO wl[156]:I wl[155]:I wl[154]:I wl[153]:I wl[152]:I wl[151]:I wl[150]:I wl[149]:I wl[148]:I wl[147]:I wl[146]:I wl[145]:I wl[144]:I wl[143]:I wl[142]:I wl[141]:I wl[140]:I wl[139]:I wl[138]:I wl[137]:I
*.PININFO wl[136]:I wl[135]:I wl[134]:I wl[133]:I wl[132]:I wl[131]:I wl[130]:I wl[129]:I wl[128]:I wl[127]:I wl[126]:I wl[125]:I wl[124]:I wl[123]:I wl[122]:I wl[121]:I wl[120]:I wl[119]:I wl[118]:I wl[117]:I
*.PININFO wl[116]:I wl[115]:I wl[114]:I wl[113]:I wl[112]:I wl[111]:I wl[110]:I wl[109]:I wl[108]:I wl[107]:I wl[106]:I wl[105]:I wl[104]:I wl[103]:I wl[102]:I wl[101]:I wl[100]:I wl[99]:I wl[98]:I wl[97]:I
*.PININFO wl[96]:I wl[95]:I wl[94]:I wl[93]:I wl[92]:I wl[91]:I wl[90]:I wl[89]:I wl[88]:I wl[87]:I wl[86]:I wl[85]:I wl[84]:I wl[83]:I wl[82]:I wl[81]:I wl[80]:I wl[79]:I wl[78]:I wl[77]:I
*.PININFO wl[76]:I wl[75]:I wl[74]:I wl[73]:I wl[72]:I wl[71]:I wl[70]:I wl[69]:I wl[68]:I wl[67]:I wl[66]:I wl[65]:I wl[64]:I wl[63]:I wl[62]:I wl[61]:I wl[60]:I wl[59]:I wl[58]:I wl[57]:I
*.PININFO wl[56]:I wl[55]:I wl[54]:I wl[53]:I wl[52]:I wl[51]:I wl[50]:I wl[49]:I wl[48]:I wl[47]:I wl[46]:I wl[45]:I wl[44]:I wl[43]:I wl[42]:I wl[41]:I wl[40]:I wl[39]:I wl[38]:I wl[37]:I
*.PININFO wl[36]:I wl[35]:I wl[34]:I wl[33]:I wl[32]:I wl[31]:I wl[30]:I wl[29]:I wl[28]:I wl[27]:I wl[26]:I wl[25]:I wl[24]:I wl[23]:I wl[22]:I wl[21]:I wl[20]:I wl[19]:I wl[18]:I wl[17]:I
*.PININFO wl[16]:I wl[15]:I wl[14]:I wl[13]:I wl[12]:I wl[11]:I wl[10]:I wl[9]:I wl[8]:I wl[7]:I wl[6]:I wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I wlred[1]:I wlred[0]:I wrwl:I
*.PININFO wrwlclkmx:O wrwlpw[1]:I wrwlpw[0]:I
Xitrkio clkwr2lnn fine_kick[3] fine_kick[2] fine_kick[1] fine_kick[0] nblkick rdwl
+ rdwlclkmx rdwlpw[3] rdwlpw[2] rdwlpw[1] rdwlpw[0] synckick syncrd syncwr trkbl
+ trkbl trkwl trkwllvlnn[2] trkwllvlnn[1] trkwllvlnn[0] vcc vssx wrwl wrwlclkmx
+ wrwlpw[1] wrwlpw[0] issahcctrkio
Xitrklfary sramvcc trkbl trkwl vssx wl[255] wl[254] wl[253] wl[252] wl[251] wl[250]
+ wl[249] wl[248] wl[247] wl[246] wl[245] wl[244] wl[243] wl[242] wl[241] wl[240]
+ wl[239] wl[238] wl[237] wl[236] wl[235] wl[234] wl[233] wl[232] wl[231] wl[230]
+ wl[229] wl[228] wl[227] wl[226] wl[225] wl[224] wl[223] wl[222] wl[221] wl[220]
+ wl[219] wl[218] wl[217] wl[216] wl[215] wl[214] wl[213] wl[212] wl[211] wl[210]
+ wl[209] wl[208] wl[207] wl[206] wl[205] wl[204] wl[203] wl[202] wl[201] wl[200]
+ wl[199] wl[198] wl[197] wl[196] wl[195] wl[194] wl[193] wl[192] wl[191] wl[190]
+ wl[189] wl[188] wl[187] wl[186] wl[185] wl[184] wl[183] wl[182] wl[181] wl[180]
+ wl[179] wl[178] wl[177] wl[176] wl[175] wl[174] wl[173] wl[172] wl[171] wl[170]
+ wl[169] wl[168] wl[167] wl[166] wl[165] wl[164] wl[163] wl[162] wl[161] wl[160]
+ wl[159] wl[158] wl[157] wl[156] wl[155] wl[154] wl[153] wl[152] wl[151] wl[150]
+ wl[149] wl[148] wl[147] wl[146] wl[145] wl[144] wl[143] wl[142] wl[141] wl[140]
+ wl[139] wl[138] wl[137] wl[136] wl[135] wl[134] wl[133] wl[132] wl[131] wl[130]
+ wl[129] wl[128] wl[127] wl[126] wl[125] wl[124] wl[123] wl[122] wl[121] wl[120]
+ wl[119] wl[118] wl[117] wl[116] wl[115] wl[114] wl[113] wl[112] wl[111] wl[110]
+ wl[109] wl[108] wl[107] wl[106] wl[105] wl[104] wl[103] wl[102] wl[101] wl[100]
+ wl[99] wl[98] wl[97] wl[96] wl[95] wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88]
+ wl[87] wl[86] wl[85] wl[84] wl[83] wl[82] wl[81] wl[80] wl[79] wl[78] wl[77] wl[76]
+ wl[75] wl[74] wl[73] wl[72] wl[71] wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64]
+ wl[63] wl[62] wl[61] wl[60] wl[59] wl[58] wl[57] wl[56] wl[55] wl[54] wl[53] wl[52]
+ wl[51] wl[50] wl[49] wl[48] wl[47] wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40]
+ wl[39] wl[38] wl[37] wl[36] wl[35] wl[34] wl[33] wl[32] wl[31] wl[30] wl[29] wl[28]
+ wl[27] wl[26] wl[25] wl[24] wl[23] wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16]
+ wl[15] wl[14] wl[13] wl[12] wl[11] wl[10] wl[9] wl[8] wl[7] wl[6] wl[5] wl[4]
+ wl[3] wl[2] wl[1] wl[0] wlred[1] wlred[0] issahccarytrk256x2
.ENDS

************************************************************************
* Library Name: ip78p6customsram
* Cell Name:    issahccary256x4
* View Name:    schematic
************************************************************************
.SUBCKT issahccary256x4 bl[3] bl[2] bl[1] bl[0] blnn[3] blnn[2] blnn[1] blnn[0] sramvcc
+ vssx wl[255] wl[254] wl[253] wl[252] wl[251] wl[250] wl[249] wl[248] wl[247] wl[246]
+ wl[245] wl[244] wl[243] wl[242] wl[241] wl[240] wl[239] wl[238] wl[237] wl[236]
+ wl[235] wl[234] wl[233] wl[232] wl[231] wl[230] wl[229] wl[228] wl[227] wl[226]
+ wl[225] wl[224] wl[223] wl[222] wl[221] wl[220] wl[219] wl[218] wl[217] wl[216]
+ wl[215] wl[214] wl[213] wl[212] wl[211] wl[210] wl[209] wl[208] wl[207] wl[206]
+ wl[205] wl[204] wl[203] wl[202] wl[201] wl[200] wl[199] wl[198] wl[197] wl[196]
+ wl[195] wl[194] wl[193] wl[192] wl[191] wl[190] wl[189] wl[188] wl[187] wl[186]
+ wl[185] wl[184] wl[183] wl[182] wl[181] wl[180] wl[179] wl[178] wl[177] wl[176]
+ wl[175] wl[174] wl[173] wl[172] wl[171] wl[170] wl[169] wl[168] wl[167] wl[166]
+ wl[165] wl[164] wl[163] wl[162] wl[161] wl[160] wl[159] wl[158] wl[157] wl[156]
+ wl[155] wl[154] wl[153] wl[152] wl[151] wl[150] wl[149] wl[148] wl[147] wl[146]
+ wl[145] wl[144] wl[143] wl[142] wl[141] wl[140] wl[139] wl[138] wl[137] wl[136]
+ wl[135] wl[134] wl[133] wl[132] wl[131] wl[130] wl[129] wl[128] wl[127] wl[126]
+ wl[125] wl[124] wl[123] wl[122] wl[121] wl[120] wl[119] wl[118] wl[117] wl[116]
+ wl[115] wl[114] wl[113] wl[112] wl[111] wl[110] wl[109] wl[108] wl[107] wl[106]
+ wl[105] wl[104] wl[103] wl[102] wl[101] wl[100] wl[99] wl[98] wl[97] wl[96] wl[95]
+ wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88] wl[87] wl[86] wl[85] wl[84] wl[83]
+ wl[82] wl[81] wl[80] wl[79] wl[78] wl[77] wl[76] wl[75] wl[74] wl[73] wl[72] wl[71]
+ wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64] wl[63] wl[62] wl[61] wl[60] wl[59]
+ wl[58] wl[57] wl[56] wl[55] wl[54] wl[53] wl[52] wl[51] wl[50] wl[49] wl[48] wl[47]
+ wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40] wl[39] wl[38] wl[37] wl[36] wl[35]
+ wl[34] wl[33] wl[32] wl[31] wl[30] wl[29] wl[28] wl[27] wl[26] wl[25] wl[24] wl[23]
+ wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16] wl[15] wl[14] wl[13] wl[12] wl[11]
+ wl[10] wl[9] wl[8] wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1] wl[0] wlred[1] wlred[0]
*.PININFO bl[3]:B bl[2]:B bl[1]:B bl[0]:B blnn[3]:B blnn[2]:B blnn[1]:B blnn[0]:B sramvcc:I vssx:I wl[255]:I wl[254]:I wl[253]:I wl[252]:I wl[251]:I wl[250]:I wl[249]:I wl[248]:I wl[247]:I wl[246]:I
*.PININFO wl[245]:I wl[244]:I wl[243]:I wl[242]:I wl[241]:I wl[240]:I wl[239]:I wl[238]:I wl[237]:I wl[236]:I wl[235]:I wl[234]:I wl[233]:I wl[232]:I wl[231]:I wl[230]:I wl[229]:I wl[228]:I wl[227]:I wl[226]:I
*.PININFO wl[225]:I wl[224]:I wl[223]:I wl[222]:I wl[221]:I wl[220]:I wl[219]:I wl[218]:I wl[217]:I wl[216]:I wl[215]:I wl[214]:I wl[213]:I wl[212]:I wl[211]:I wl[210]:I wl[209]:I wl[208]:I wl[207]:I wl[206]:I
*.PININFO wl[205]:I wl[204]:I wl[203]:I wl[202]:I wl[201]:I wl[200]:I wl[199]:I wl[198]:I wl[197]:I wl[196]:I wl[195]:I wl[194]:I wl[193]:I wl[192]:I wl[191]:I wl[190]:I wl[189]:I wl[188]:I wl[187]:I wl[186]:I
*.PININFO wl[185]:I wl[184]:I wl[183]:I wl[182]:I wl[181]:I wl[180]:I wl[179]:I wl[178]:I wl[177]:I wl[176]:I wl[175]:I wl[174]:I wl[173]:I wl[172]:I wl[171]:I wl[170]:I wl[169]:I wl[168]:I wl[167]:I wl[166]:I
*.PININFO wl[165]:I wl[164]:I wl[163]:I wl[162]:I wl[161]:I wl[160]:I wl[159]:I wl[158]:I wl[157]:I wl[156]:I wl[155]:I wl[154]:I wl[153]:I wl[152]:I wl[151]:I wl[150]:I wl[149]:I wl[148]:I wl[147]:I wl[146]:I
*.PININFO wl[145]:I wl[144]:I wl[143]:I wl[142]:I wl[141]:I wl[140]:I wl[139]:I wl[138]:I wl[137]:I wl[136]:I wl[135]:I wl[134]:I wl[133]:I wl[132]:I wl[131]:I wl[130]:I wl[129]:I wl[128]:I wl[127]:I wl[126]:I
*.PININFO wl[125]:I wl[124]:I wl[123]:I wl[122]:I wl[121]:I wl[120]:I wl[119]:I wl[118]:I wl[117]:I wl[116]:I wl[115]:I wl[114]:I wl[113]:I wl[112]:I wl[111]:I wl[110]:I wl[109]:I wl[108]:I wl[107]:I wl[106]:I
*.PININFO wl[105]:I wl[104]:I wl[103]:I wl[102]:I wl[101]:I wl[100]:I wl[99]:I wl[98]:I wl[97]:I wl[96]:I wl[95]:I wl[94]:I wl[93]:I wl[92]:I wl[91]:I wl[90]:I wl[89]:I wl[88]:I wl[87]:I wl[86]:I
*.PININFO wl[85]:I wl[84]:I wl[83]:I wl[82]:I wl[81]:I wl[80]:I wl[79]:I wl[78]:I wl[77]:I wl[76]:I wl[75]:I wl[74]:I wl[73]:I wl[72]:I wl[71]:I wl[70]:I wl[69]:I wl[68]:I wl[67]:I wl[66]:I
*.PININFO wl[65]:I wl[64]:I wl[63]:I wl[62]:I wl[61]:I wl[60]:I wl[59]:I wl[58]:I wl[57]:I wl[56]:I wl[55]:I wl[54]:I wl[53]:I wl[52]:I wl[51]:I wl[50]:I wl[49]:I wl[48]:I wl[47]:I wl[46]:I
*.PININFO wl[45]:I wl[44]:I wl[43]:I wl[42]:I wl[41]:I wl[40]:I wl[39]:I wl[38]:I wl[37]:I wl[36]:I wl[35]:I wl[34]:I wl[33]:I wl[32]:I wl[31]:I wl[30]:I wl[29]:I wl[28]:I wl[27]:I wl[26]:I
*.PININFO wl[25]:I wl[24]:I wl[23]:I wl[22]:I wl[21]:I wl[20]:I wl[19]:I wl[18]:I wl[17]:I wl[16]:I wl[15]:I wl[14]:I wl[13]:I wl[12]:I wl[11]:I wl[10]:I wl[9]:I wl[8]:I wl[7]:I wl[6]:I
*.PININFO wl[5]:I wl[4]:I wl[3]:I wl[2]:I wl[1]:I wl[0]:I wlred[1]:I wlred[0]:I
Xiaryedge1x4lf bl[3] bl[2] bl[1] bl[0] sramvcc sramvcc sramvcc sramvcc vssx issahccedg1x4
Xibitedge1x4rt bl[3] bl[2] bl[1] bl[0] sramvcc sramvcc sramvcc sramvcc vssx issahccedg1x4
Xiredun bl[3] bl[2] bl[1] bl[0] blnn[3] blnn[2] blnn[1] blnn[0] sramvcc vssx wlred[1]
+ wlred[0] issahccbit2x4
Xiary128x4rt bl[3] bl[2] bl[1] bl[0] blnn[3] blnn[2] blnn[1] blnn[0] sramvcc vssx
+ wl[127] wl[126] wl[125] wl[124] wl[123] wl[122] wl[121] wl[120] wl[119] wl[118]
+ wl[117] wl[116] wl[115] wl[114] wl[113] wl[112] wl[111] wl[110] wl[109] wl[108]
+ wl[107] wl[106] wl[105] wl[104] wl[103] wl[102] wl[101] wl[100] wl[99] wl[98]
+ wl[97] wl[96] wl[95] wl[94] wl[93] wl[92] wl[91] wl[90] wl[89] wl[88] wl[87] wl[86]
+ wl[85] wl[84] wl[83] wl[82] wl[81] wl[80] wl[79] wl[78] wl[77] wl[76] wl[75] wl[74]
+ wl[73] wl[72] wl[71] wl[70] wl[69] wl[68] wl[67] wl[66] wl[65] wl[64] wl[63] wl[62]
+ wl[61] wl[60] wl[59] wl[58] wl[57] wl[56] wl[55] wl[54] wl[53] wl[52] wl[51] wl[50]
+ wl[49] wl[48] wl[47] wl[46] wl[45] wl[44] wl[43] wl[42] wl[41] wl[40] wl[39] wl[38]
+ wl[37] wl[36] wl[35] wl[34] wl[33] wl[32] wl[31] wl[30] wl[29] wl[28] wl[27] wl[26]
+ wl[25] wl[24] wl[23] wl[22] wl[21] wl[20] wl[19] wl[18] wl[17] wl[16] wl[15] wl[14]
+ wl[13] wl[12] wl[11] wl[10] wl[9] wl[8] wl[7] wl[6] wl[5] wl[4] wl[3] wl[2] wl[1]
+ wl[0] issahccaryi128x4
Xiary128x4lf bl[3] bl[2] bl[1] bl[0] blnn[3] blnn[2] blnn[1] blnn[0] sramvcc vssx
+ wl[255] wl[254] wl[253] wl[252] wl[251] wl[250] wl[249] wl[248] wl[247] wl[246]
+ wl[245] wl[244] wl[243] wl[242] wl[241] wl[240] wl[239] wl[238] wl[237] wl[236]
+ wl[235] wl[234] wl[233] wl[232] wl[231] wl[230] wl[229] wl[228] wl[227] wl[226]
+ wl[225] wl[224] wl[223] wl[222] wl[221] wl[220] wl[219] wl[218] wl[217] wl[216]
+ wl[215] wl[214] wl[213] wl[212] wl[211] wl[210] wl[209] wl[208] wl[207] wl[206]
+ wl[205] wl[204] wl[203] wl[202] wl[201] wl[200] wl[199] wl[198] wl[197] wl[196]
+ wl[195] wl[194] wl[193] wl[192] wl[191] wl[190] wl[189] wl[188] wl[187] wl[186]
+ wl[185] wl[184] wl[183] wl[182] wl[181] wl[180] wl[179] wl[178] wl[177] wl[176]
+ wl[175] wl[174] wl[173] wl[172] wl[171] wl[170] wl[169] wl[168] wl[167] wl[166]
+ wl[165] wl[164] wl[163] wl[162] wl[161] wl[160] wl[159] wl[158] wl[157] wl[156]
+ wl[155] wl[154] wl[153] wl[152] wl[151] wl[150] wl[149] wl[148] wl[147] wl[146]
+ wl[145] wl[144] wl[143] wl[142] wl[141] wl[140] wl[139] wl[138] wl[137] wl[136]
+ wl[135] wl[134] wl[133] wl[132] wl[131] wl[130] wl[129] wl[128] issahccaryi128x4
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_cntrl activered#[1] activered#[0] bankgrant1h
+ clkbank clkwrsynckicknn finekick[3] finekick[2] finekick[1] finekick[0] fz_asynckick#
+ fz_asyncrd# fz_asyncwr# fz_finekick#[3] fz_finekick#[2] fz_finekick#[1] fz_finekick#[0]
+ fz_rassel#[2] fz_rassel#[1] fz_rassel#[0] fz_rdwlcut# fz_rdwlpw#[3] fz_rdwlpw#[2]
+ fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw#[1] fz_saepw#[0] fz_synckick fz_syncrd fz_syncwr
+ fz_trbwassel#[2] fz_trbwassel#[1] fz_trbwassel#[0] fz_trkwllvl#[2] fz_trkwllvl#[1]
+ fz_trkwllvl#[0] fz_wassel#[2] fz_wassel#[1] fz_wassel#[0] fz_wrwlcut# fz_wrwlpw#[1]
+ fz_wrwlpw#[0] grant1l grant2h ia_hi#[2] ia_hi#[1] ia_hi#[0] ia_mid#[2] ia_mid#[1]
+ ia_mid#[0] ia_wle#[1] ia_wle#[0] iwren1h iwren1l2l iwren2h3h lyaennn lyanowl#
+ lyasel nbl_kicknn_dn nbl_kicknn_up nblkick pcnn0_dn pcnn0_up pcnn1_dn pcnn1_up
+ rdwl rdwlclkmx rdwlpw[3] rdwlpw[2] rdwlpw[1] rdwlpw[0] rdysel0_dn[3] rdysel0_dn[2]
+ rdysel0_dn[1] rdysel0_dn[0] rdysel0_up[3] rdysel0_up[2] rdysel0_up[1] rdysel0_up[0]
+ rdysel1_dn[3] rdysel1_dn[2] rdysel1_dn[1] rdysel1_dn[0] rdysel1_up[3] rdysel1_up[2]
+ rdysel1_up[1] rdysel1_up[0] redwl0_dn[1] redwl0_dn[0] redwl0_up[1] redwl0_up[0]
+ redwl1_dn[1] redwl1_dn[0] redwl1_up[1] redwl1_up[0] saenn_dn saenn_up sapchnn_dn
+ sapchnn_up sideen[0] trkwllvlnn[2] trkwllvlnn[1] trkwllvlnn[0] turbomode# vcc
+ vss waenn_dn[2] waenn_dn[1] waenn_dn[0] waenn_up[2] waenn_up[1] waenn_up[0] wayselbnk[3]
+ wayselbnk[2] wayselbnk[1] wayselbnk[0] wl0_dn[255] wl0_dn[254] wl0_dn[253] wl0_dn[252]
+ wl0_dn[251] wl0_dn[250] wl0_dn[249] wl0_dn[248] wl0_dn[247] wl0_dn[246] wl0_dn[245]
+ wl0_dn[244] wl0_dn[243] wl0_dn[242] wl0_dn[241] wl0_dn[240] wl0_dn[239] wl0_dn[238]
+ wl0_dn[237] wl0_dn[236] wl0_dn[235] wl0_dn[234] wl0_dn[233] wl0_dn[232] wl0_dn[231]
+ wl0_dn[230] wl0_dn[229] wl0_dn[228] wl0_dn[227] wl0_dn[226] wl0_dn[225] wl0_dn[224]
+ wl0_dn[223] wl0_dn[222] wl0_dn[221] wl0_dn[220] wl0_dn[219] wl0_dn[218] wl0_dn[217]
+ wl0_dn[216] wl0_dn[215] wl0_dn[214] wl0_dn[213] wl0_dn[212] wl0_dn[211] wl0_dn[210]
+ wl0_dn[209] wl0_dn[208] wl0_dn[207] wl0_dn[206] wl0_dn[205] wl0_dn[204] wl0_dn[203]
+ wl0_dn[202] wl0_dn[201] wl0_dn[200] wl0_dn[199] wl0_dn[198] wl0_dn[197] wl0_dn[196]
+ wl0_dn[195] wl0_dn[194] wl0_dn[193] wl0_dn[192] wl0_dn[191] wl0_dn[190] wl0_dn[189]
+ wl0_dn[188] wl0_dn[187] wl0_dn[186] wl0_dn[185] wl0_dn[184] wl0_dn[183] wl0_dn[182]
+ wl0_dn[181] wl0_dn[180] wl0_dn[179] wl0_dn[178] wl0_dn[177] wl0_dn[176] wl0_dn[175]
+ wl0_dn[174] wl0_dn[173] wl0_dn[172] wl0_dn[171] wl0_dn[170] wl0_dn[169] wl0_dn[168]
+ wl0_dn[167] wl0_dn[166] wl0_dn[165] wl0_dn[164] wl0_dn[163] wl0_dn[162] wl0_dn[161]
+ wl0_dn[160] wl0_dn[159] wl0_dn[158] wl0_dn[157] wl0_dn[156] wl0_dn[155] wl0_dn[154]
+ wl0_dn[153] wl0_dn[152] wl0_dn[151] wl0_dn[150] wl0_dn[149] wl0_dn[148] wl0_dn[147]
+ wl0_dn[146] wl0_dn[145] wl0_dn[144] wl0_dn[143] wl0_dn[142] wl0_dn[141] wl0_dn[140]
+ wl0_dn[139] wl0_dn[138] wl0_dn[137] wl0_dn[136] wl0_dn[135] wl0_dn[134] wl0_dn[133]
+ wl0_dn[132] wl0_dn[131] wl0_dn[130] wl0_dn[129] wl0_dn[128] wl0_dn[127] wl0_dn[126]
+ wl0_dn[125] wl0_dn[124] wl0_dn[123] wl0_dn[122] wl0_dn[121] wl0_dn[120] wl0_dn[119]
+ wl0_dn[118] wl0_dn[117] wl0_dn[116] wl0_dn[115] wl0_dn[114] wl0_dn[113] wl0_dn[112]
+ wl0_dn[111] wl0_dn[110] wl0_dn[109] wl0_dn[108] wl0_dn[107] wl0_dn[106] wl0_dn[105]
+ wl0_dn[104] wl0_dn[103] wl0_dn[102] wl0_dn[101] wl0_dn[100] wl0_dn[99] wl0_dn[98]
+ wl0_dn[97] wl0_dn[96] wl0_dn[95] wl0_dn[94] wl0_dn[93] wl0_dn[92] wl0_dn[91] wl0_dn[90]
+ wl0_dn[89] wl0_dn[88] wl0_dn[87] wl0_dn[86] wl0_dn[85] wl0_dn[84] wl0_dn[83] wl0_dn[82]
+ wl0_dn[81] wl0_dn[80] wl0_dn[79] wl0_dn[78] wl0_dn[77] wl0_dn[76] wl0_dn[75] wl0_dn[74]
+ wl0_dn[73] wl0_dn[72] wl0_dn[71] wl0_dn[70] wl0_dn[69] wl0_dn[68] wl0_dn[67] wl0_dn[66]
+ wl0_dn[65] wl0_dn[64] wl0_dn[63] wl0_dn[62] wl0_dn[61] wl0_dn[60] wl0_dn[59] wl0_dn[58]
+ wl0_dn[57] wl0_dn[56] wl0_dn[55] wl0_dn[54] wl0_dn[53] wl0_dn[52] wl0_dn[51] wl0_dn[50]
+ wl0_dn[49] wl0_dn[48] wl0_dn[47] wl0_dn[46] wl0_dn[45] wl0_dn[44] wl0_dn[43] wl0_dn[42]
+ wl0_dn[41] wl0_dn[40] wl0_dn[39] wl0_dn[38] wl0_dn[37] wl0_dn[36] wl0_dn[35] wl0_dn[34]
+ wl0_dn[33] wl0_dn[32] wl0_dn[31] wl0_dn[30] wl0_dn[29] wl0_dn[28] wl0_dn[27] wl0_dn[26]
+ wl0_dn[25] wl0_dn[24] wl0_dn[23] wl0_dn[22] wl0_dn[21] wl0_dn[20] wl0_dn[19] wl0_dn[18]
+ wl0_dn[17] wl0_dn[16] wl0_dn[15] wl0_dn[14] wl0_dn[13] wl0_dn[12] wl0_dn[11] wl0_dn[10]
+ wl0_dn[9] wl0_dn[8] wl0_dn[7] wl0_dn[6] wl0_dn[5] wl0_dn[4] wl0_dn[3] wl0_dn[2]
+ wl0_dn[1] wl0_dn[0] wl0_up[255] wl0_up[254] wl0_up[253] wl0_up[252] wl0_up[251]
+ wl0_up[250] wl0_up[249] wl0_up[248] wl0_up[247] wl0_up[246] wl0_up[245] wl0_up[244]
+ wl0_up[243] wl0_up[242] wl0_up[241] wl0_up[240] wl0_up[239] wl0_up[238] wl0_up[237]
+ wl0_up[236] wl0_up[235] wl0_up[234] wl0_up[233] wl0_up[232] wl0_up[231] wl0_up[230]
+ wl0_up[229] wl0_up[228] wl0_up[227] wl0_up[226] wl0_up[225] wl0_up[224] wl0_up[223]
+ wl0_up[222] wl0_up[221] wl0_up[220] wl0_up[219] wl0_up[218] wl0_up[217] wl0_up[216]
+ wl0_up[215] wl0_up[214] wl0_up[213] wl0_up[212] wl0_up[211] wl0_up[210] wl0_up[209]
+ wl0_up[208] wl0_up[207] wl0_up[206] wl0_up[205] wl0_up[204] wl0_up[203] wl0_up[202]
+ wl0_up[201] wl0_up[200] wl0_up[199] wl0_up[198] wl0_up[197] wl0_up[196] wl0_up[195]
+ wl0_up[194] wl0_up[193] wl0_up[192] wl0_up[191] wl0_up[190] wl0_up[189] wl0_up[188]
+ wl0_up[187] wl0_up[186] wl0_up[185] wl0_up[184] wl0_up[183] wl0_up[182] wl0_up[181]
+ wl0_up[180] wl0_up[179] wl0_up[178] wl0_up[177] wl0_up[176] wl0_up[175] wl0_up[174]
+ wl0_up[173] wl0_up[172] wl0_up[171] wl0_up[170] wl0_up[169] wl0_up[168] wl0_up[167]
+ wl0_up[166] wl0_up[165] wl0_up[164] wl0_up[163] wl0_up[162] wl0_up[161] wl0_up[160]
+ wl0_up[159] wl0_up[158] wl0_up[157] wl0_up[156] wl0_up[155] wl0_up[154] wl0_up[153]
+ wl0_up[152] wl0_up[151] wl0_up[150] wl0_up[149] wl0_up[148] wl0_up[147] wl0_up[146]
+ wl0_up[145] wl0_up[144] wl0_up[143] wl0_up[142] wl0_up[141] wl0_up[140] wl0_up[139]
+ wl0_up[138] wl0_up[137] wl0_up[136] wl0_up[135] wl0_up[134] wl0_up[133] wl0_up[132]
+ wl0_up[131] wl0_up[130] wl0_up[129] wl0_up[128] wl0_up[127] wl0_up[126] wl0_up[125]
+ wl0_up[124] wl0_up[123] wl0_up[122] wl0_up[121] wl0_up[120] wl0_up[119] wl0_up[118]
+ wl0_up[117] wl0_up[116] wl0_up[115] wl0_up[114] wl0_up[113] wl0_up[112] wl0_up[111]
+ wl0_up[110] wl0_up[109] wl0_up[108] wl0_up[107] wl0_up[106] wl0_up[105] wl0_up[104]
+ wl0_up[103] wl0_up[102] wl0_up[101] wl0_up[100] wl0_up[99] wl0_up[98] wl0_up[97]
+ wl0_up[96] wl0_up[95] wl0_up[94] wl0_up[93] wl0_up[92] wl0_up[91] wl0_up[90] wl0_up[89]
+ wl0_up[88] wl0_up[87] wl0_up[86] wl0_up[85] wl0_up[84] wl0_up[83] wl0_up[82] wl0_up[81]
+ wl0_up[80] wl0_up[79] wl0_up[78] wl0_up[77] wl0_up[76] wl0_up[75] wl0_up[74] wl0_up[73]
+ wl0_up[72] wl0_up[71] wl0_up[70] wl0_up[69] wl0_up[68] wl0_up[67] wl0_up[66] wl0_up[65]
+ wl0_up[64] wl0_up[63] wl0_up[62] wl0_up[61] wl0_up[60] wl0_up[59] wl0_up[58] wl0_up[57]
+ wl0_up[56] wl0_up[55] wl0_up[54] wl0_up[53] wl0_up[52] wl0_up[51] wl0_up[50] wl0_up[49]
+ wl0_up[48] wl0_up[47] wl0_up[46] wl0_up[45] wl0_up[44] wl0_up[43] wl0_up[42] wl0_up[41]
+ wl0_up[40] wl0_up[39] wl0_up[38] wl0_up[37] wl0_up[36] wl0_up[35] wl0_up[34] wl0_up[33]
+ wl0_up[32] wl0_up[31] wl0_up[30] wl0_up[29] wl0_up[28] wl0_up[27] wl0_up[26] wl0_up[25]
+ wl0_up[24] wl0_up[23] wl0_up[22] wl0_up[21] wl0_up[20] wl0_up[19] wl0_up[18] wl0_up[17]
+ wl0_up[16] wl0_up[15] wl0_up[14] wl0_up[13] wl0_up[12] wl0_up[11] wl0_up[10] wl0_up[9]
+ wl0_up[8] wl0_up[7] wl0_up[6] wl0_up[5] wl0_up[4] wl0_up[3] wl0_up[2] wl0_up[1]
+ wl0_up[0] wl1_dn[255] wl1_dn[254] wl1_dn[253] wl1_dn[252] wl1_dn[251] wl1_dn[250]
+ wl1_dn[249] wl1_dn[248] wl1_dn[247] wl1_dn[246] wl1_dn[245] wl1_dn[244] wl1_dn[243]
+ wl1_dn[242] wl1_dn[241] wl1_dn[240] wl1_dn[239] wl1_dn[238] wl1_dn[237] wl1_dn[236]
+ wl1_dn[235] wl1_dn[234] wl1_dn[233] wl1_dn[232] wl1_dn[231] wl1_dn[230] wl1_dn[229]
+ wl1_dn[228] wl1_dn[227] wl1_dn[226] wl1_dn[225] wl1_dn[224] wl1_dn[223] wl1_dn[222]
+ wl1_dn[221] wl1_dn[220] wl1_dn[219] wl1_dn[218] wl1_dn[217] wl1_dn[216] wl1_dn[215]
+ wl1_dn[214] wl1_dn[213] wl1_dn[212] wl1_dn[211] wl1_dn[210] wl1_dn[209] wl1_dn[208]
+ wl1_dn[207] wl1_dn[206] wl1_dn[205] wl1_dn[204] wl1_dn[203] wl1_dn[202] wl1_dn[201]
+ wl1_dn[200] wl1_dn[199] wl1_dn[198] wl1_dn[197] wl1_dn[196] wl1_dn[195] wl1_dn[194]
+ wl1_dn[193] wl1_dn[192] wl1_dn[191] wl1_dn[190] wl1_dn[189] wl1_dn[188] wl1_dn[187]
+ wl1_dn[186] wl1_dn[185] wl1_dn[184] wl1_dn[183] wl1_dn[182] wl1_dn[181] wl1_dn[180]
+ wl1_dn[179] wl1_dn[178] wl1_dn[177] wl1_dn[176] wl1_dn[175] wl1_dn[174] wl1_dn[173]
+ wl1_dn[172] wl1_dn[171] wl1_dn[170] wl1_dn[169] wl1_dn[168] wl1_dn[167] wl1_dn[166]
+ wl1_dn[165] wl1_dn[164] wl1_dn[163] wl1_dn[162] wl1_dn[161] wl1_dn[160] wl1_dn[159]
+ wl1_dn[158] wl1_dn[157] wl1_dn[156] wl1_dn[155] wl1_dn[154] wl1_dn[153] wl1_dn[152]
+ wl1_dn[151] wl1_dn[150] wl1_dn[149] wl1_dn[148] wl1_dn[147] wl1_dn[146] wl1_dn[145]
+ wl1_dn[144] wl1_dn[143] wl1_dn[142] wl1_dn[141] wl1_dn[140] wl1_dn[139] wl1_dn[138]
+ wl1_dn[137] wl1_dn[136] wl1_dn[135] wl1_dn[134] wl1_dn[133] wl1_dn[132] wl1_dn[131]
+ wl1_dn[130] wl1_dn[129] wl1_dn[128] wl1_dn[127] wl1_dn[126] wl1_dn[125] wl1_dn[124]
+ wl1_dn[123] wl1_dn[122] wl1_dn[121] wl1_dn[120] wl1_dn[119] wl1_dn[118] wl1_dn[117]
+ wl1_dn[116] wl1_dn[115] wl1_dn[114] wl1_dn[113] wl1_dn[112] wl1_dn[111] wl1_dn[110]
+ wl1_dn[109] wl1_dn[108] wl1_dn[107] wl1_dn[106] wl1_dn[105] wl1_dn[104] wl1_dn[103]
+ wl1_dn[102] wl1_dn[101] wl1_dn[100] wl1_dn[99] wl1_dn[98] wl1_dn[97] wl1_dn[96]
+ wl1_dn[95] wl1_dn[94] wl1_dn[93] wl1_dn[92] wl1_dn[91] wl1_dn[90] wl1_dn[89] wl1_dn[88]
+ wl1_dn[87] wl1_dn[86] wl1_dn[85] wl1_dn[84] wl1_dn[83] wl1_dn[82] wl1_dn[81] wl1_dn[80]
+ wl1_dn[79] wl1_dn[78] wl1_dn[77] wl1_dn[76] wl1_dn[75] wl1_dn[74] wl1_dn[73] wl1_dn[72]
+ wl1_dn[71] wl1_dn[70] wl1_dn[69] wl1_dn[68] wl1_dn[67] wl1_dn[66] wl1_dn[65] wl1_dn[64]
+ wl1_dn[63] wl1_dn[62] wl1_dn[61] wl1_dn[60] wl1_dn[59] wl1_dn[58] wl1_dn[57] wl1_dn[56]
+ wl1_dn[55] wl1_dn[54] wl1_dn[53] wl1_dn[52] wl1_dn[51] wl1_dn[50] wl1_dn[49] wl1_dn[48]
+ wl1_dn[47] wl1_dn[46] wl1_dn[45] wl1_dn[44] wl1_dn[43] wl1_dn[42] wl1_dn[41] wl1_dn[40]
+ wl1_dn[39] wl1_dn[38] wl1_dn[37] wl1_dn[36] wl1_dn[35] wl1_dn[34] wl1_dn[33] wl1_dn[32]
+ wl1_dn[31] wl1_dn[30] wl1_dn[29] wl1_dn[28] wl1_dn[27] wl1_dn[26] wl1_dn[25] wl1_dn[24]
+ wl1_dn[23] wl1_dn[22] wl1_dn[21] wl1_dn[20] wl1_dn[19] wl1_dn[18] wl1_dn[17] wl1_dn[16]
+ wl1_dn[15] wl1_dn[14] wl1_dn[13] wl1_dn[12] wl1_dn[11] wl1_dn[10] wl1_dn[9] wl1_dn[8]
+ wl1_dn[7] wl1_dn[6] wl1_dn[5] wl1_dn[4] wl1_dn[3] wl1_dn[2] wl1_dn[1] wl1_dn[0]
+ wl1_up[255] wl1_up[254] wl1_up[253] wl1_up[252] wl1_up[251] wl1_up[250] wl1_up[249]
+ wl1_up[248] wl1_up[247] wl1_up[246] wl1_up[245] wl1_up[244] wl1_up[243] wl1_up[242]
+ wl1_up[241] wl1_up[240] wl1_up[239] wl1_up[238] wl1_up[237] wl1_up[236] wl1_up[235]
+ wl1_up[234] wl1_up[233] wl1_up[232] wl1_up[231] wl1_up[230] wl1_up[229] wl1_up[228]
+ wl1_up[227] wl1_up[226] wl1_up[225] wl1_up[224] wl1_up[223] wl1_up[222] wl1_up[221]
+ wl1_up[220] wl1_up[219] wl1_up[218] wl1_up[217] wl1_up[216] wl1_up[215] wl1_up[214]
+ wl1_up[213] wl1_up[212] wl1_up[211] wl1_up[210] wl1_up[209] wl1_up[208] wl1_up[207]
+ wl1_up[206] wl1_up[205] wl1_up[204] wl1_up[203] wl1_up[202] wl1_up[201] wl1_up[200]
+ wl1_up[199] wl1_up[198] wl1_up[197] wl1_up[196] wl1_up[195] wl1_up[194] wl1_up[193]
+ wl1_up[192] wl1_up[191] wl1_up[190] wl1_up[189] wl1_up[188] wl1_up[187] wl1_up[186]
+ wl1_up[185] wl1_up[184] wl1_up[183] wl1_up[182] wl1_up[181] wl1_up[180] wl1_up[179]
+ wl1_up[178] wl1_up[177] wl1_up[176] wl1_up[175] wl1_up[174] wl1_up[173] wl1_up[172]
+ wl1_up[171] wl1_up[170] wl1_up[169] wl1_up[168] wl1_up[167] wl1_up[166] wl1_up[165]
+ wl1_up[164] wl1_up[163] wl1_up[162] wl1_up[161] wl1_up[160] wl1_up[159] wl1_up[158]
+ wl1_up[157] wl1_up[156] wl1_up[155] wl1_up[154] wl1_up[153] wl1_up[152] wl1_up[151]
+ wl1_up[150] wl1_up[149] wl1_up[148] wl1_up[147] wl1_up[146] wl1_up[145] wl1_up[144]
+ wl1_up[143] wl1_up[142] wl1_up[141] wl1_up[140] wl1_up[139] wl1_up[138] wl1_up[137]
+ wl1_up[136] wl1_up[135] wl1_up[134] wl1_up[133] wl1_up[132] wl1_up[131] wl1_up[130]
+ wl1_up[129] wl1_up[128] wl1_up[127] wl1_up[126] wl1_up[125] wl1_up[124] wl1_up[123]
+ wl1_up[122] wl1_up[121] wl1_up[120] wl1_up[119] wl1_up[118] wl1_up[117] wl1_up[116]
+ wl1_up[115] wl1_up[114] wl1_up[113] wl1_up[112] wl1_up[111] wl1_up[110] wl1_up[109]
+ wl1_up[108] wl1_up[107] wl1_up[106] wl1_up[105] wl1_up[104] wl1_up[103] wl1_up[102]
+ wl1_up[101] wl1_up[100] wl1_up[99] wl1_up[98] wl1_up[97] wl1_up[96] wl1_up[95]
+ wl1_up[94] wl1_up[93] wl1_up[92] wl1_up[91] wl1_up[90] wl1_up[89] wl1_up[88] wl1_up[87]
+ wl1_up[86] wl1_up[85] wl1_up[84] wl1_up[83] wl1_up[82] wl1_up[81] wl1_up[80] wl1_up[79]
+ wl1_up[78] wl1_up[77] wl1_up[76] wl1_up[75] wl1_up[74] wl1_up[73] wl1_up[72] wl1_up[71]
+ wl1_up[70] wl1_up[69] wl1_up[68] wl1_up[67] wl1_up[66] wl1_up[65] wl1_up[64] wl1_up[63]
+ wl1_up[62] wl1_up[61] wl1_up[60] wl1_up[59] wl1_up[58] wl1_up[57] wl1_up[56] wl1_up[55]
+ wl1_up[54] wl1_up[53] wl1_up[52] wl1_up[51] wl1_up[50] wl1_up[49] wl1_up[48] wl1_up[47]
+ wl1_up[46] wl1_up[45] wl1_up[44] wl1_up[43] wl1_up[42] wl1_up[41] wl1_up[40] wl1_up[39]
+ wl1_up[38] wl1_up[37] wl1_up[36] wl1_up[35] wl1_up[34] wl1_up[33] wl1_up[32] wl1_up[31]
+ wl1_up[30] wl1_up[29] wl1_up[28] wl1_up[27] wl1_up[26] wl1_up[25] wl1_up[24] wl1_up[23]
+ wl1_up[22] wl1_up[21] wl1_up[20] wl1_up[19] wl1_up[18] wl1_up[17] wl1_up[16] wl1_up[15]
+ wl1_up[14] wl1_up[13] wl1_up[12] wl1_up[11] wl1_up[10] wl1_up[9] wl1_up[8] wl1_up[7]
+ wl1_up[6] wl1_up[5] wl1_up[4] wl1_up[3] wl1_up[2] wl1_up[1] wl1_up[0] wrclk_dn
+ wrclk_up wrcolsel0_dn[3] wrcolsel0_dn[2] wrcolsel0_dn[1] wrcolsel0_dn[0] wrcolsel0_up[3]
+ wrcolsel0_up[2] wrcolsel0_up[1] wrcolsel0_up[0] wrcolsel1_dn[3] wrcolsel1_dn[2]
+ wrcolsel1_dn[1] wrcolsel1_dn[0] wrcolsel1_up[3] wrcolsel1_up[2] wrcolsel1_up[1]
+ wrcolsel1_up[0] wrdataen_dn wrdataen_up wrwl wrwlclkmx wrwlpw[1] wrwlpw[0]
*.PININFO activered#[1]:I activered#[0]:I bankgrant1h:I clkbank:I clkwrsynckicknn:O finekick[3]:O finekick[2]:O finekick[1]:O finekick[0]:O fz_asynckick#:I fz_asyncrd#:I fz_asyncwr#:I fz_finekick#[3]:I fz_finekick#[2]:I fz_finekick#[1]:I fz_finekick#[0]:I fz_rassel#[2]:I fz_rassel#[1]:I fz_rassel#[0]:I fz_rdwlcut#:I
*.PININFO fz_rdwlpw#[3]:I fz_rdwlpw#[2]:I fz_rdwlpw#[1]:I fz_rdwlpw#[0]:I fz_saepw#[1]:I fz_saepw#[0]:I fz_synckick:O fz_syncrd:O fz_syncwr:O fz_trbwassel#[2]:I fz_trbwassel#[1]:I fz_trbwassel#[0]:I fz_trkwllvl#[2]:I fz_trkwllvl#[1]:I fz_trkwllvl#[0]:I fz_wassel#[2]:I fz_wassel#[1]:I fz_wassel#[0]:I fz_wrwlcut#:I fz_wrwlpw#[1]:I
*.PININFO fz_wrwlpw#[0]:I grant1l:I grant2h:I ia_hi#[2]:I ia_hi#[1]:I ia_hi#[0]:I ia_mid#[2]:I ia_mid#[1]:I ia_mid#[0]:I ia_wle#[1]:I ia_wle#[0]:I iwren1h:I iwren1l2l:I iwren2h3h:I lyaennn:O lyanowl#:I lyasel:I nbl_kicknn_dn:O nbl_kicknn_up:O nblkick:I
*.PININFO pcnn0_dn:O pcnn0_up:O pcnn1_dn:O pcnn1_up:O rdwl:O rdwlclkmx:I rdwlpw[3]:O rdwlpw[2]:O rdwlpw[1]:O rdwlpw[0]:O rdysel0_dn[3]:O rdysel0_dn[2]:O rdysel0_dn[1]:O rdysel0_dn[0]:O rdysel0_up[3]:O rdysel0_up[2]:O rdysel0_up[1]:O rdysel0_up[0]:O rdysel1_dn[3]:O rdysel1_dn[2]:O
*.PININFO rdysel1_dn[1]:O rdysel1_dn[0]:O rdysel1_up[3]:O rdysel1_up[2]:O rdysel1_up[1]:O rdysel1_up[0]:O redwl0_dn[1]:O redwl0_dn[0]:O redwl0_up[1]:O redwl0_up[0]:O redwl1_dn[1]:O redwl1_dn[0]:O redwl1_up[1]:O redwl1_up[0]:O saenn_dn:O saenn_up:O sapchnn_dn:O sapchnn_up:O sideen[0]:I trkwllvlnn[2]:O
*.PININFO trkwllvlnn[1]:O trkwllvlnn[0]:O turbomode#:I vcc:I vss:I waenn_dn[2]:O waenn_dn[1]:O waenn_dn[0]:O waenn_up[2]:O waenn_up[1]:O waenn_up[0]:O wayselbnk[3]:I wayselbnk[2]:I wayselbnk[1]:I wayselbnk[0]:I wl0_dn[255]:O wl0_dn[254]:O wl0_dn[253]:O wl0_dn[252]:O wl0_dn[251]:O
*.PININFO wl0_dn[250]:O wl0_dn[249]:O wl0_dn[248]:O wl0_dn[247]:O wl0_dn[246]:O wl0_dn[245]:O wl0_dn[244]:O wl0_dn[243]:O wl0_dn[242]:O wl0_dn[241]:O wl0_dn[240]:O wl0_dn[239]:O wl0_dn[238]:O wl0_dn[237]:O wl0_dn[236]:O wl0_dn[235]:O wl0_dn[234]:O wl0_dn[233]:O wl0_dn[232]:O wl0_dn[231]:O
*.PININFO wl0_dn[230]:O wl0_dn[229]:O wl0_dn[228]:O wl0_dn[227]:O wl0_dn[226]:O wl0_dn[225]:O wl0_dn[224]:O wl0_dn[223]:O wl0_dn[222]:O wl0_dn[221]:O wl0_dn[220]:O wl0_dn[219]:O wl0_dn[218]:O wl0_dn[217]:O wl0_dn[216]:O wl0_dn[215]:O wl0_dn[214]:O wl0_dn[213]:O wl0_dn[212]:O wl0_dn[211]:O
*.PININFO wl0_dn[210]:O wl0_dn[209]:O wl0_dn[208]:O wl0_dn[207]:O wl0_dn[206]:O wl0_dn[205]:O wl0_dn[204]:O wl0_dn[203]:O wl0_dn[202]:O wl0_dn[201]:O wl0_dn[200]:O wl0_dn[199]:O wl0_dn[198]:O wl0_dn[197]:O wl0_dn[196]:O wl0_dn[195]:O wl0_dn[194]:O wl0_dn[193]:O wl0_dn[192]:O wl0_dn[191]:O
*.PININFO wl0_dn[190]:O wl0_dn[189]:O wl0_dn[188]:O wl0_dn[187]:O wl0_dn[186]:O wl0_dn[185]:O wl0_dn[184]:O wl0_dn[183]:O wl0_dn[182]:O wl0_dn[181]:O wl0_dn[180]:O wl0_dn[179]:O wl0_dn[178]:O wl0_dn[177]:O wl0_dn[176]:O wl0_dn[175]:O wl0_dn[174]:O wl0_dn[173]:O wl0_dn[172]:O wl0_dn[171]:O
*.PININFO wl0_dn[170]:O wl0_dn[169]:O wl0_dn[168]:O wl0_dn[167]:O wl0_dn[166]:O wl0_dn[165]:O wl0_dn[164]:O wl0_dn[163]:O wl0_dn[162]:O wl0_dn[161]:O wl0_dn[160]:O wl0_dn[159]:O wl0_dn[158]:O wl0_dn[157]:O wl0_dn[156]:O wl0_dn[155]:O wl0_dn[154]:O wl0_dn[153]:O wl0_dn[152]:O wl0_dn[151]:O
*.PININFO wl0_dn[150]:O wl0_dn[149]:O wl0_dn[148]:O wl0_dn[147]:O wl0_dn[146]:O wl0_dn[145]:O wl0_dn[144]:O wl0_dn[143]:O wl0_dn[142]:O wl0_dn[141]:O wl0_dn[140]:O wl0_dn[139]:O wl0_dn[138]:O wl0_dn[137]:O wl0_dn[136]:O wl0_dn[135]:O wl0_dn[134]:O wl0_dn[133]:O wl0_dn[132]:O wl0_dn[131]:O
*.PININFO wl0_dn[130]:O wl0_dn[129]:O wl0_dn[128]:O wl0_dn[127]:O wl0_dn[126]:O wl0_dn[125]:O wl0_dn[124]:O wl0_dn[123]:O wl0_dn[122]:O wl0_dn[121]:O wl0_dn[120]:O wl0_dn[119]:O wl0_dn[118]:O wl0_dn[117]:O wl0_dn[116]:O wl0_dn[115]:O wl0_dn[114]:O wl0_dn[113]:O wl0_dn[112]:O wl0_dn[111]:O
*.PININFO wl0_dn[110]:O wl0_dn[109]:O wl0_dn[108]:O wl0_dn[107]:O wl0_dn[106]:O wl0_dn[105]:O wl0_dn[104]:O wl0_dn[103]:O wl0_dn[102]:O wl0_dn[101]:O wl0_dn[100]:O wl0_dn[99]:O wl0_dn[98]:O wl0_dn[97]:O wl0_dn[96]:O wl0_dn[95]:O wl0_dn[94]:O wl0_dn[93]:O wl0_dn[92]:O wl0_dn[91]:O
*.PININFO wl0_dn[90]:O wl0_dn[89]:O wl0_dn[88]:O wl0_dn[87]:O wl0_dn[86]:O wl0_dn[85]:O wl0_dn[84]:O wl0_dn[83]:O wl0_dn[82]:O wl0_dn[81]:O wl0_dn[80]:O wl0_dn[79]:O wl0_dn[78]:O wl0_dn[77]:O wl0_dn[76]:O wl0_dn[75]:O wl0_dn[74]:O wl0_dn[73]:O wl0_dn[72]:O wl0_dn[71]:O
*.PININFO wl0_dn[70]:O wl0_dn[69]:O wl0_dn[68]:O wl0_dn[67]:O wl0_dn[66]:O wl0_dn[65]:O wl0_dn[64]:O wl0_dn[63]:O wl0_dn[62]:O wl0_dn[61]:O wl0_dn[60]:O wl0_dn[59]:O wl0_dn[58]:O wl0_dn[57]:O wl0_dn[56]:O wl0_dn[55]:O wl0_dn[54]:O wl0_dn[53]:O wl0_dn[52]:O wl0_dn[51]:O
*.PININFO wl0_dn[50]:O wl0_dn[49]:O wl0_dn[48]:O wl0_dn[47]:O wl0_dn[46]:O wl0_dn[45]:O wl0_dn[44]:O wl0_dn[43]:O wl0_dn[42]:O wl0_dn[41]:O wl0_dn[40]:O wl0_dn[39]:O wl0_dn[38]:O wl0_dn[37]:O wl0_dn[36]:O wl0_dn[35]:O wl0_dn[34]:O wl0_dn[33]:O wl0_dn[32]:O wl0_dn[31]:O
*.PININFO wl0_dn[30]:O wl0_dn[29]:O wl0_dn[28]:O wl0_dn[27]:O wl0_dn[26]:O wl0_dn[25]:O wl0_dn[24]:O wl0_dn[23]:O wl0_dn[22]:O wl0_dn[21]:O wl0_dn[20]:O wl0_dn[19]:O wl0_dn[18]:O wl0_dn[17]:O wl0_dn[16]:O wl0_dn[15]:O wl0_dn[14]:O wl0_dn[13]:O wl0_dn[12]:O wl0_dn[11]:O
*.PININFO wl0_dn[10]:O wl0_dn[9]:O wl0_dn[8]:O wl0_dn[7]:O wl0_dn[6]:O wl0_dn[5]:O wl0_dn[4]:O wl0_dn[3]:O wl0_dn[2]:O wl0_dn[1]:O wl0_dn[0]:O wl0_up[255]:O wl0_up[254]:O wl0_up[253]:O wl0_up[252]:O wl0_up[251]:O wl0_up[250]:O wl0_up[249]:O wl0_up[248]:O wl0_up[247]:O
*.PININFO wl0_up[246]:O wl0_up[245]:O wl0_up[244]:O wl0_up[243]:O wl0_up[242]:O wl0_up[241]:O wl0_up[240]:O wl0_up[239]:O wl0_up[238]:O wl0_up[237]:O wl0_up[236]:O wl0_up[235]:O wl0_up[234]:O wl0_up[233]:O wl0_up[232]:O wl0_up[231]:O wl0_up[230]:O wl0_up[229]:O wl0_up[228]:O wl0_up[227]:O
*.PININFO wl0_up[226]:O wl0_up[225]:O wl0_up[224]:O wl0_up[223]:O wl0_up[222]:O wl0_up[221]:O wl0_up[220]:O wl0_up[219]:O wl0_up[218]:O wl0_up[217]:O wl0_up[216]:O wl0_up[215]:O wl0_up[214]:O wl0_up[213]:O wl0_up[212]:O wl0_up[211]:O wl0_up[210]:O wl0_up[209]:O wl0_up[208]:O wl0_up[207]:O
*.PININFO wl0_up[206]:O wl0_up[205]:O wl0_up[204]:O wl0_up[203]:O wl0_up[202]:O wl0_up[201]:O wl0_up[200]:O wl0_up[199]:O wl0_up[198]:O wl0_up[197]:O wl0_up[196]:O wl0_up[195]:O wl0_up[194]:O wl0_up[193]:O wl0_up[192]:O wl0_up[191]:O wl0_up[190]:O wl0_up[189]:O wl0_up[188]:O wl0_up[187]:O
*.PININFO wl0_up[186]:O wl0_up[185]:O wl0_up[184]:O wl0_up[183]:O wl0_up[182]:O wl0_up[181]:O wl0_up[180]:O wl0_up[179]:O wl0_up[178]:O wl0_up[177]:O wl0_up[176]:O wl0_up[175]:O wl0_up[174]:O wl0_up[173]:O wl0_up[172]:O wl0_up[171]:O wl0_up[170]:O wl0_up[169]:O wl0_up[168]:O wl0_up[167]:O
*.PININFO wl0_up[166]:O wl0_up[165]:O wl0_up[164]:O wl0_up[163]:O wl0_up[162]:O wl0_up[161]:O wl0_up[160]:O wl0_up[159]:O wl0_up[158]:O wl0_up[157]:O wl0_up[156]:O wl0_up[155]:O wl0_up[154]:O wl0_up[153]:O wl0_up[152]:O wl0_up[151]:O wl0_up[150]:O wl0_up[149]:O wl0_up[148]:O wl0_up[147]:O
*.PININFO wl0_up[146]:O wl0_up[145]:O wl0_up[144]:O wl0_up[143]:O wl0_up[142]:O wl0_up[141]:O wl0_up[140]:O wl0_up[139]:O wl0_up[138]:O wl0_up[137]:O wl0_up[136]:O wl0_up[135]:O wl0_up[134]:O wl0_up[133]:O wl0_up[132]:O wl0_up[131]:O wl0_up[130]:O wl0_up[129]:O wl0_up[128]:O wl0_up[127]:O
*.PININFO wl0_up[126]:O wl0_up[125]:O wl0_up[124]:O wl0_up[123]:O wl0_up[122]:O wl0_up[121]:O wl0_up[120]:O wl0_up[119]:O wl0_up[118]:O wl0_up[117]:O wl0_up[116]:O wl0_up[115]:O wl0_up[114]:O wl0_up[113]:O wl0_up[112]:O wl0_up[111]:O wl0_up[110]:O wl0_up[109]:O wl0_up[108]:O wl0_up[107]:O
*.PININFO wl0_up[106]:O wl0_up[105]:O wl0_up[104]:O wl0_up[103]:O wl0_up[102]:O wl0_up[101]:O wl0_up[100]:O wl0_up[99]:O wl0_up[98]:O wl0_up[97]:O wl0_up[96]:O wl0_up[95]:O wl0_up[94]:O wl0_up[93]:O wl0_up[92]:O wl0_up[91]:O wl0_up[90]:O wl0_up[89]:O wl0_up[88]:O wl0_up[87]:O
*.PININFO wl0_up[86]:O wl0_up[85]:O wl0_up[84]:O wl0_up[83]:O wl0_up[82]:O wl0_up[81]:O wl0_up[80]:O wl0_up[79]:O wl0_up[78]:O wl0_up[77]:O wl0_up[76]:O wl0_up[75]:O wl0_up[74]:O wl0_up[73]:O wl0_up[72]:O wl0_up[71]:O wl0_up[70]:O wl0_up[69]:O wl0_up[68]:O wl0_up[67]:O
*.PININFO wl0_up[66]:O wl0_up[65]:O wl0_up[64]:O wl0_up[63]:O wl0_up[62]:O wl0_up[61]:O wl0_up[60]:O wl0_up[59]:O wl0_up[58]:O wl0_up[57]:O wl0_up[56]:O wl0_up[55]:O wl0_up[54]:O wl0_up[53]:O wl0_up[52]:O wl0_up[51]:O wl0_up[50]:O wl0_up[49]:O wl0_up[48]:O wl0_up[47]:O
*.PININFO wl0_up[46]:O wl0_up[45]:O wl0_up[44]:O wl0_up[43]:O wl0_up[42]:O wl0_up[41]:O wl0_up[40]:O wl0_up[39]:O wl0_up[38]:O wl0_up[37]:O wl0_up[36]:O wl0_up[35]:O wl0_up[34]:O wl0_up[33]:O wl0_up[32]:O wl0_up[31]:O wl0_up[30]:O wl0_up[29]:O wl0_up[28]:O wl0_up[27]:O
*.PININFO wl0_up[26]:O wl0_up[25]:O wl0_up[24]:O wl0_up[23]:O wl0_up[22]:O wl0_up[21]:O wl0_up[20]:O wl0_up[19]:O wl0_up[18]:O wl0_up[17]:O wl0_up[16]:O wl0_up[15]:O wl0_up[14]:O wl0_up[13]:O wl0_up[12]:O wl0_up[11]:O wl0_up[10]:O wl0_up[9]:O wl0_up[8]:O wl0_up[7]:O
*.PININFO wl0_up[6]:O wl0_up[5]:O wl0_up[4]:O wl0_up[3]:O wl0_up[2]:O wl0_up[1]:O wl0_up[0]:O wl1_dn[255]:O wl1_dn[254]:O wl1_dn[253]:O wl1_dn[252]:O wl1_dn[251]:O wl1_dn[250]:O wl1_dn[249]:O wl1_dn[248]:O wl1_dn[247]:O wl1_dn[246]:O wl1_dn[245]:O wl1_dn[244]:O wl1_dn[243]:O
*.PININFO wl1_dn[242]:O wl1_dn[241]:O wl1_dn[240]:O wl1_dn[239]:O wl1_dn[238]:O wl1_dn[237]:O wl1_dn[236]:O wl1_dn[235]:O wl1_dn[234]:O wl1_dn[233]:O wl1_dn[232]:O wl1_dn[231]:O wl1_dn[230]:O wl1_dn[229]:O wl1_dn[228]:O wl1_dn[227]:O wl1_dn[226]:O wl1_dn[225]:O wl1_dn[224]:O wl1_dn[223]:O
*.PININFO wl1_dn[222]:O wl1_dn[221]:O wl1_dn[220]:O wl1_dn[219]:O wl1_dn[218]:O wl1_dn[217]:O wl1_dn[216]:O wl1_dn[215]:O wl1_dn[214]:O wl1_dn[213]:O wl1_dn[212]:O wl1_dn[211]:O wl1_dn[210]:O wl1_dn[209]:O wl1_dn[208]:O wl1_dn[207]:O wl1_dn[206]:O wl1_dn[205]:O wl1_dn[204]:O wl1_dn[203]:O
*.PININFO wl1_dn[202]:O wl1_dn[201]:O wl1_dn[200]:O wl1_dn[199]:O wl1_dn[198]:O wl1_dn[197]:O wl1_dn[196]:O wl1_dn[195]:O wl1_dn[194]:O wl1_dn[193]:O wl1_dn[192]:O wl1_dn[191]:O wl1_dn[190]:O wl1_dn[189]:O wl1_dn[188]:O wl1_dn[187]:O wl1_dn[186]:O wl1_dn[185]:O wl1_dn[184]:O wl1_dn[183]:O
*.PININFO wl1_dn[182]:O wl1_dn[181]:O wl1_dn[180]:O wl1_dn[179]:O wl1_dn[178]:O wl1_dn[177]:O wl1_dn[176]:O wl1_dn[175]:O wl1_dn[174]:O wl1_dn[173]:O wl1_dn[172]:O wl1_dn[171]:O wl1_dn[170]:O wl1_dn[169]:O wl1_dn[168]:O wl1_dn[167]:O wl1_dn[166]:O wl1_dn[165]:O wl1_dn[164]:O wl1_dn[163]:O
*.PININFO wl1_dn[162]:O wl1_dn[161]:O wl1_dn[160]:O wl1_dn[159]:O wl1_dn[158]:O wl1_dn[157]:O wl1_dn[156]:O wl1_dn[155]:O wl1_dn[154]:O wl1_dn[153]:O wl1_dn[152]:O wl1_dn[151]:O wl1_dn[150]:O wl1_dn[149]:O wl1_dn[148]:O wl1_dn[147]:O wl1_dn[146]:O wl1_dn[145]:O wl1_dn[144]:O wl1_dn[143]:O
*.PININFO wl1_dn[142]:O wl1_dn[141]:O wl1_dn[140]:O wl1_dn[139]:O wl1_dn[138]:O wl1_dn[137]:O wl1_dn[136]:O wl1_dn[135]:O wl1_dn[134]:O wl1_dn[133]:O wl1_dn[132]:O wl1_dn[131]:O wl1_dn[130]:O wl1_dn[129]:O wl1_dn[128]:O wl1_dn[127]:O wl1_dn[126]:O wl1_dn[125]:O wl1_dn[124]:O wl1_dn[123]:O
*.PININFO wl1_dn[122]:O wl1_dn[121]:O wl1_dn[120]:O wl1_dn[119]:O wl1_dn[118]:O wl1_dn[117]:O wl1_dn[116]:O wl1_dn[115]:O wl1_dn[114]:O wl1_dn[113]:O wl1_dn[112]:O wl1_dn[111]:O wl1_dn[110]:O wl1_dn[109]:O wl1_dn[108]:O wl1_dn[107]:O wl1_dn[106]:O wl1_dn[105]:O wl1_dn[104]:O wl1_dn[103]:O
*.PININFO wl1_dn[102]:O wl1_dn[101]:O wl1_dn[100]:O wl1_dn[99]:O wl1_dn[98]:O wl1_dn[97]:O wl1_dn[96]:O wl1_dn[95]:O wl1_dn[94]:O wl1_dn[93]:O wl1_dn[92]:O wl1_dn[91]:O wl1_dn[90]:O wl1_dn[89]:O wl1_dn[88]:O wl1_dn[87]:O wl1_dn[86]:O wl1_dn[85]:O wl1_dn[84]:O wl1_dn[83]:O
*.PININFO wl1_dn[82]:O wl1_dn[81]:O wl1_dn[80]:O wl1_dn[79]:O wl1_dn[78]:O wl1_dn[77]:O wl1_dn[76]:O wl1_dn[75]:O wl1_dn[74]:O wl1_dn[73]:O wl1_dn[72]:O wl1_dn[71]:O wl1_dn[70]:O wl1_dn[69]:O wl1_dn[68]:O wl1_dn[67]:O wl1_dn[66]:O wl1_dn[65]:O wl1_dn[64]:O wl1_dn[63]:O
*.PININFO wl1_dn[62]:O wl1_dn[61]:O wl1_dn[60]:O wl1_dn[59]:O wl1_dn[58]:O wl1_dn[57]:O wl1_dn[56]:O wl1_dn[55]:O wl1_dn[54]:O wl1_dn[53]:O wl1_dn[52]:O wl1_dn[51]:O wl1_dn[50]:O wl1_dn[49]:O wl1_dn[48]:O wl1_dn[47]:O wl1_dn[46]:O wl1_dn[45]:O wl1_dn[44]:O wl1_dn[43]:O
*.PININFO wl1_dn[42]:O wl1_dn[41]:O wl1_dn[40]:O wl1_dn[39]:O wl1_dn[38]:O wl1_dn[37]:O wl1_dn[36]:O wl1_dn[35]:O wl1_dn[34]:O wl1_dn[33]:O wl1_dn[32]:O wl1_dn[31]:O wl1_dn[30]:O wl1_dn[29]:O wl1_dn[28]:O wl1_dn[27]:O wl1_dn[26]:O wl1_dn[25]:O wl1_dn[24]:O wl1_dn[23]:O
*.PININFO wl1_dn[22]:O wl1_dn[21]:O wl1_dn[20]:O wl1_dn[19]:O wl1_dn[18]:O wl1_dn[17]:O wl1_dn[16]:O wl1_dn[15]:O wl1_dn[14]:O wl1_dn[13]:O wl1_dn[12]:O wl1_dn[11]:O wl1_dn[10]:O wl1_dn[9]:O wl1_dn[8]:O wl1_dn[7]:O wl1_dn[6]:O wl1_dn[5]:O wl1_dn[4]:O wl1_dn[3]:O
*.PININFO wl1_dn[2]:O wl1_dn[1]:O wl1_dn[0]:O wl1_up[255]:O wl1_up[254]:O wl1_up[253]:O wl1_up[252]:O wl1_up[251]:O wl1_up[250]:O wl1_up[249]:O wl1_up[248]:O wl1_up[247]:O wl1_up[246]:O wl1_up[245]:O wl1_up[244]:O wl1_up[243]:O wl1_up[242]:O wl1_up[241]:O wl1_up[240]:O wl1_up[239]:O
*.PININFO wl1_up[238]:O wl1_up[237]:O wl1_up[236]:O wl1_up[235]:O wl1_up[234]:O wl1_up[233]:O wl1_up[232]:O wl1_up[231]:O wl1_up[230]:O wl1_up[229]:O wl1_up[228]:O wl1_up[227]:O wl1_up[226]:O wl1_up[225]:O wl1_up[224]:O wl1_up[223]:O wl1_up[222]:O wl1_up[221]:O wl1_up[220]:O wl1_up[219]:O
*.PININFO wl1_up[218]:O wl1_up[217]:O wl1_up[216]:O wl1_up[215]:O wl1_up[214]:O wl1_up[213]:O wl1_up[212]:O wl1_up[211]:O wl1_up[210]:O wl1_up[209]:O wl1_up[208]:O wl1_up[207]:O wl1_up[206]:O wl1_up[205]:O wl1_up[204]:O wl1_up[203]:O wl1_up[202]:O wl1_up[201]:O wl1_up[200]:O wl1_up[199]:O
*.PININFO wl1_up[198]:O wl1_up[197]:O wl1_up[196]:O wl1_up[195]:O wl1_up[194]:O wl1_up[193]:O wl1_up[192]:O wl1_up[191]:O wl1_up[190]:O wl1_up[189]:O wl1_up[188]:O wl1_up[187]:O wl1_up[186]:O wl1_up[185]:O wl1_up[184]:O wl1_up[183]:O wl1_up[182]:O wl1_up[181]:O wl1_up[180]:O wl1_up[179]:O
*.PININFO wl1_up[178]:O wl1_up[177]:O wl1_up[176]:O wl1_up[175]:O wl1_up[174]:O wl1_up[173]:O wl1_up[172]:O wl1_up[171]:O wl1_up[170]:O wl1_up[169]:O wl1_up[168]:O wl1_up[167]:O wl1_up[166]:O wl1_up[165]:O wl1_up[164]:O wl1_up[163]:O wl1_up[162]:O wl1_up[161]:O wl1_up[160]:O wl1_up[159]:O
*.PININFO wl1_up[158]:O wl1_up[157]:O wl1_up[156]:O wl1_up[155]:O wl1_up[154]:O wl1_up[153]:O wl1_up[152]:O wl1_up[151]:O wl1_up[150]:O wl1_up[149]:O wl1_up[148]:O wl1_up[147]:O wl1_up[146]:O wl1_up[145]:O wl1_up[144]:O wl1_up[143]:O wl1_up[142]:O wl1_up[141]:O wl1_up[140]:O wl1_up[139]:O
*.PININFO wl1_up[138]:O wl1_up[137]:O wl1_up[136]:O wl1_up[135]:O wl1_up[134]:O wl1_up[133]:O wl1_up[132]:O wl1_up[131]:O wl1_up[130]:O wl1_up[129]:O wl1_up[128]:O wl1_up[127]:O wl1_up[126]:O wl1_up[125]:O wl1_up[124]:O wl1_up[123]:O wl1_up[122]:O wl1_up[121]:O wl1_up[120]:O wl1_up[119]:O
*.PININFO wl1_up[118]:O wl1_up[117]:O wl1_up[116]:O wl1_up[115]:O wl1_up[114]:O wl1_up[113]:O wl1_up[112]:O wl1_up[111]:O wl1_up[110]:O wl1_up[109]:O wl1_up[108]:O wl1_up[107]:O wl1_up[106]:O wl1_up[105]:O wl1_up[104]:O wl1_up[103]:O wl1_up[102]:O wl1_up[101]:O wl1_up[100]:O wl1_up[99]:O
*.PININFO wl1_up[98]:O wl1_up[97]:O wl1_up[96]:O wl1_up[95]:O wl1_up[94]:O wl1_up[93]:O wl1_up[92]:O wl1_up[91]:O wl1_up[90]:O wl1_up[89]:O wl1_up[88]:O wl1_up[87]:O wl1_up[86]:O wl1_up[85]:O wl1_up[84]:O wl1_up[83]:O wl1_up[82]:O wl1_up[81]:O wl1_up[80]:O wl1_up[79]:O
*.PININFO wl1_up[78]:O wl1_up[77]:O wl1_up[76]:O wl1_up[75]:O wl1_up[74]:O wl1_up[73]:O wl1_up[72]:O wl1_up[71]:O wl1_up[70]:O wl1_up[69]:O wl1_up[68]:O wl1_up[67]:O wl1_up[66]:O wl1_up[65]:O wl1_up[64]:O wl1_up[63]:O wl1_up[62]:O wl1_up[61]:O wl1_up[60]:O wl1_up[59]:O
*.PININFO wl1_up[58]:O wl1_up[57]:O wl1_up[56]:O wl1_up[55]:O wl1_up[54]:O wl1_up[53]:O wl1_up[52]:O wl1_up[51]:O wl1_up[50]:O wl1_up[49]:O wl1_up[48]:O wl1_up[47]:O wl1_up[46]:O wl1_up[45]:O wl1_up[44]:O wl1_up[43]:O wl1_up[42]:O wl1_up[41]:O wl1_up[40]:O wl1_up[39]:O
*.PININFO wl1_up[38]:O wl1_up[37]:O wl1_up[36]:O wl1_up[35]:O wl1_up[34]:O wl1_up[33]:O wl1_up[32]:O wl1_up[31]:O wl1_up[30]:O wl1_up[29]:O wl1_up[28]:O wl1_up[27]:O wl1_up[26]:O wl1_up[25]:O wl1_up[24]:O wl1_up[23]:O wl1_up[22]:O wl1_up[21]:O wl1_up[20]:O wl1_up[19]:O
*.PININFO wl1_up[18]:O wl1_up[17]:O wl1_up[16]:O wl1_up[15]:O wl1_up[14]:O wl1_up[13]:O wl1_up[12]:O wl1_up[11]:O wl1_up[10]:O wl1_up[9]:O wl1_up[8]:O wl1_up[7]:O wl1_up[6]:O wl1_up[5]:O wl1_up[4]:O wl1_up[3]:O wl1_up[2]:O wl1_up[1]:O wl1_up[0]:O wrclk_dn:O
*.PININFO wrclk_up:O wrcolsel0_dn[3]:O wrcolsel0_dn[2]:O wrcolsel0_dn[1]:O wrcolsel0_dn[0]:O wrcolsel0_up[3]:O wrcolsel0_up[2]:O wrcolsel0_up[1]:O wrcolsel0_up[0]:O wrcolsel1_dn[3]:O wrcolsel1_dn[2]:O wrcolsel1_dn[1]:O wrcolsel1_dn[0]:O wrcolsel1_up[3]:O wrcolsel1_up[2]:O wrcolsel1_up[1]:O wrcolsel1_up[0]:O wrdataen_dn:O wrdataen_up:O wrwl:O
*.PININFO wrwlclkmx:I wrwlpw[1]:O wrwlpw[0]:O
Xtimer activered#[1] activered#[0] bankgrant1h clkbank clkwrsynckicknn finekick[3]
+ finekick[2] finekick[1] finekick[0] fz_asynckick# fz_asyncrd# fz_asyncwr# fz_finekick#[3]
+ fz_finekick#[2] fz_finekick#[1] fz_finekick#[0] fz_rassel#[2] fz_rassel#[1] fz_rassel#[0]
+ fz_rdwlcut# fz_rdwlpw#[3] fz_rdwlpw#[2] fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw#[1]
+ fz_saepw#[0] fz_synckick fz_syncrd fz_syncwr fz_trbwassel#[2] fz_trbwassel#[1]
+ fz_trbwassel#[0] fz_trkwllvl#[2] fz_trkwllvl#[1] fz_trkwllvl#[0] fz_wassel#[2]
+ fz_wassel#[1] fz_wassel#[0] fz_wrwlcut# fz_wrwlpw#[1] fz_wrwlpw#[0] grant1l grant2h
+ hi#[7] hi#[6] hi#[5] hi#[4] hi#[3] hi#[2] hi#[1] hi#[0] ia_hi#[2] ia_hi#[1] ia_hi#[0]
+ ia_mid#[2] ia_mid#[1] ia_mid#[0] ia_wle#[1] ia_wle#[0] iwren1h iwren1l2l iwren2h3h
+ lyaennn lyanowl# lyasel mid#[7] mid#[6] mid#[5] mid#[4] mid#[3] mid#[2] mid#[1]
+ mid#[0] nbl_kicknn_dn nbl_kicknn_up nblkick pcnn0_dn pcnn0_up pcnn1_dn pcnn1_up
+ rdwl rdwlclkmx rdwlpw[3] rdwlpw[2] rdwlpw[1] rdwlpw[0] rdysel0_dn[3] rdysel0_dn[2]
+ rdysel0_dn[1] rdysel0_dn[0] rdysel0_up[3] rdysel0_up[2] rdysel0_up[1] rdysel0_up[0]
+ rdysel1_dn[3] rdysel1_dn[2] rdysel1_dn[1] rdysel1_dn[0] rdysel1_up[3] rdysel1_up[2]
+ rdysel1_up[1] rdysel1_up[0] saenn_dn saenn_up sapchnn_dn sapchnn_up sideen[0]
+ slpen0 slpen1 trkwllvlnn[2] trkwllvlnn[1] trkwllvlnn[0] turbomode# vcc vss waenn_dn[2]
+ waenn_dn[1] waenn_dn[0] waenn_up[2] waenn_up[1] waenn_up[0] wayselbnk[3] wayselbnk[2]
+ wayselbnk[1] wayselbnk[0] wle0[3] wle0[2] wle0[1] wle0[0] wle1[3] wle1[2] wle1[1]
+ wle1[0] wlered0[1] wlered0[0] wlered1[1] wlered1[0] wllvlnn[2] wllvlnn[1] wllvlnn[0]
+ wrclk_dn wrclk_up wrcolsel0_dn[3] wrcolsel0_dn[2] wrcolsel0_dn[1] wrcolsel0_dn[0]
+ wrcolsel0_up[3] wrcolsel0_up[2] wrcolsel0_up[1] wrcolsel0_up[0] wrcolsel1_dn[3]
+ wrcolsel1_dn[2] wrcolsel1_dn[1] wrcolsel1_dn[0] wrcolsel1_up[3] wrcolsel1_up[2]
+ wrcolsel1_up[1] wrcolsel1_up[0] wrdataen_dn wrdataen_up wrwl wrwlclkmx wrwlpw[1]
+ wrwlpw[0] ip78d6hcf2sr4096x135m4i2k4w8r2lya_timer
Xdec0 vss vss vss hi#[7] hi#[6] hi#[5] hi#[4] hi#[3] hi#[2] hi#[1] hi#[0] mid#[7]
+ mid#[6] mid#[5] mid#[4] mid#[3] mid#[2] mid#[1] mid#[0] slpen0 vcc vss wl0_dn[127]
+ wl0_dn[126] wl0_dn[125] wl0_dn[124] wl0_dn[123] wl0_dn[122] wl0_dn[121] wl0_dn[120]
+ wl0_dn[119] wl0_dn[118] wl0_dn[117] wl0_dn[116] wl0_dn[115] wl0_dn[114] wl0_dn[113]
+ wl0_dn[112] wl0_dn[111] wl0_dn[110] wl0_dn[109] wl0_dn[108] wl0_dn[107] wl0_dn[106]
+ wl0_dn[105] wl0_dn[104] wl0_dn[103] wl0_dn[102] wl0_dn[101] wl0_dn[100] wl0_dn[99]
+ wl0_dn[98] wl0_dn[97] wl0_dn[96] wl0_dn[95] wl0_dn[94] wl0_dn[93] wl0_dn[92] wl0_dn[91]
+ wl0_dn[90] wl0_dn[89] wl0_dn[88] wl0_dn[87] wl0_dn[86] wl0_dn[85] wl0_dn[84] wl0_dn[83]
+ wl0_dn[82] wl0_dn[81] wl0_dn[80] wl0_dn[79] wl0_dn[78] wl0_dn[77] wl0_dn[76] wl0_dn[75]
+ wl0_dn[74] wl0_dn[73] wl0_dn[72] wl0_dn[71] wl0_dn[70] wl0_dn[69] wl0_dn[68] wl0_dn[67]
+ wl0_dn[66] wl0_dn[65] wl0_dn[64] wl0_dn[63] wl0_dn[62] wl0_dn[61] wl0_dn[60] wl0_dn[59]
+ wl0_dn[58] wl0_dn[57] wl0_dn[56] wl0_dn[55] wl0_dn[54] wl0_dn[53] wl0_dn[52] wl0_dn[51]
+ wl0_dn[50] wl0_dn[49] wl0_dn[48] wl0_dn[47] wl0_dn[46] wl0_dn[45] wl0_dn[44] wl0_dn[43]
+ wl0_dn[42] wl0_dn[41] wl0_dn[40] wl0_dn[39] wl0_dn[38] wl0_dn[37] wl0_dn[36] wl0_dn[35]
+ wl0_dn[34] wl0_dn[33] wl0_dn[32] wl0_dn[31] wl0_dn[30] wl0_dn[29] wl0_dn[28] wl0_dn[27]
+ wl0_dn[26] wl0_dn[25] wl0_dn[24] wl0_dn[23] wl0_dn[22] wl0_dn[21] wl0_dn[20] wl0_dn[19]
+ wl0_dn[18] wl0_dn[17] wl0_dn[16] wl0_dn[15] wl0_dn[14] wl0_dn[13] wl0_dn[12] wl0_dn[11]
+ wl0_dn[10] wl0_dn[9] wl0_dn[8] wl0_dn[7] wl0_dn[6] wl0_dn[5] wl0_dn[4] wl0_dn[3]
+ wl0_dn[2] wl0_dn[1] wl0_dn[0] wl0_dn[255] wl0_dn[254] wl0_dn[253] wl0_dn[252]
+ wl0_dn[251] wl0_dn[250] wl0_dn[249] wl0_dn[248] wl0_dn[247] wl0_dn[246] wl0_dn[245]
+ wl0_dn[244] wl0_dn[243] wl0_dn[242] wl0_dn[241] wl0_dn[240] wl0_dn[239] wl0_dn[238]
+ wl0_dn[237] wl0_dn[236] wl0_dn[235] wl0_dn[234] wl0_dn[233] wl0_dn[232] wl0_dn[231]
+ wl0_dn[230] wl0_dn[229] wl0_dn[228] wl0_dn[227] wl0_dn[226] wl0_dn[225] wl0_dn[224]
+ wl0_dn[223] wl0_dn[222] wl0_dn[221] wl0_dn[220] wl0_dn[219] wl0_dn[218] wl0_dn[217]
+ wl0_dn[216] wl0_dn[215] wl0_dn[214] wl0_dn[213] wl0_dn[212] wl0_dn[211] wl0_dn[210]
+ wl0_dn[209] wl0_dn[208] wl0_dn[207] wl0_dn[206] wl0_dn[205] wl0_dn[204] wl0_dn[203]
+ wl0_dn[202] wl0_dn[201] wl0_dn[200] wl0_dn[199] wl0_dn[198] wl0_dn[197] wl0_dn[196]
+ wl0_dn[195] wl0_dn[194] wl0_dn[193] wl0_dn[192] wl0_dn[191] wl0_dn[190] wl0_dn[189]
+ wl0_dn[188] wl0_dn[187] wl0_dn[186] wl0_dn[185] wl0_dn[184] wl0_dn[183] wl0_dn[182]
+ wl0_dn[181] wl0_dn[180] wl0_dn[179] wl0_dn[178] wl0_dn[177] wl0_dn[176] wl0_dn[175]
+ wl0_dn[174] wl0_dn[173] wl0_dn[172] wl0_dn[171] wl0_dn[170] wl0_dn[169] wl0_dn[168]
+ wl0_dn[167] wl0_dn[166] wl0_dn[165] wl0_dn[164] wl0_dn[163] wl0_dn[162] wl0_dn[161]
+ wl0_dn[160] wl0_dn[159] wl0_dn[158] wl0_dn[157] wl0_dn[156] wl0_dn[155] wl0_dn[154]
+ wl0_dn[153] wl0_dn[152] wl0_dn[151] wl0_dn[150] wl0_dn[149] wl0_dn[148] wl0_dn[147]
+ wl0_dn[146] wl0_dn[145] wl0_dn[144] wl0_dn[143] wl0_dn[142] wl0_dn[141] wl0_dn[140]
+ wl0_dn[139] wl0_dn[138] wl0_dn[137] wl0_dn[136] wl0_dn[135] wl0_dn[134] wl0_dn[133]
+ wl0_dn[132] wl0_dn[131] wl0_dn[130] wl0_dn[129] wl0_dn[128] wle0[3] wle0[2] wle0[1]
+ wle0[0] wlered0[1] wlered0[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] redwl0_dn[1] redwl0_dn[0]
+ redwl0_up[1] redwl0_up[0] wl0_up[127] wl0_up[126] wl0_up[125] wl0_up[124] wl0_up[123]
+ wl0_up[122] wl0_up[121] wl0_up[120] wl0_up[119] wl0_up[118] wl0_up[117] wl0_up[116]
+ wl0_up[115] wl0_up[114] wl0_up[113] wl0_up[112] wl0_up[111] wl0_up[110] wl0_up[109]
+ wl0_up[108] wl0_up[107] wl0_up[106] wl0_up[105] wl0_up[104] wl0_up[103] wl0_up[102]
+ wl0_up[101] wl0_up[100] wl0_up[99] wl0_up[98] wl0_up[97] wl0_up[96] wl0_up[95]
+ wl0_up[94] wl0_up[93] wl0_up[92] wl0_up[91] wl0_up[90] wl0_up[89] wl0_up[88] wl0_up[87]
+ wl0_up[86] wl0_up[85] wl0_up[84] wl0_up[83] wl0_up[82] wl0_up[81] wl0_up[80] wl0_up[79]
+ wl0_up[78] wl0_up[77] wl0_up[76] wl0_up[75] wl0_up[74] wl0_up[73] wl0_up[72] wl0_up[71]
+ wl0_up[70] wl0_up[69] wl0_up[68] wl0_up[67] wl0_up[66] wl0_up[65] wl0_up[64] wl0_up[63]
+ wl0_up[62] wl0_up[61] wl0_up[60] wl0_up[59] wl0_up[58] wl0_up[57] wl0_up[56] wl0_up[55]
+ wl0_up[54] wl0_up[53] wl0_up[52] wl0_up[51] wl0_up[50] wl0_up[49] wl0_up[48] wl0_up[47]
+ wl0_up[46] wl0_up[45] wl0_up[44] wl0_up[43] wl0_up[42] wl0_up[41] wl0_up[40] wl0_up[39]
+ wl0_up[38] wl0_up[37] wl0_up[36] wl0_up[35] wl0_up[34] wl0_up[33] wl0_up[32] wl0_up[31]
+ wl0_up[30] wl0_up[29] wl0_up[28] wl0_up[27] wl0_up[26] wl0_up[25] wl0_up[24] wl0_up[23]
+ wl0_up[22] wl0_up[21] wl0_up[20] wl0_up[19] wl0_up[18] wl0_up[17] wl0_up[16] wl0_up[15]
+ wl0_up[14] wl0_up[13] wl0_up[12] wl0_up[11] wl0_up[10] wl0_up[9] wl0_up[8] wl0_up[7]
+ wl0_up[6] wl0_up[5] wl0_up[4] wl0_up[3] wl0_up[2] wl0_up[1] wl0_up[0] wl0_up[255]
+ wl0_up[254] wl0_up[253] wl0_up[252] wl0_up[251] wl0_up[250] wl0_up[249] wl0_up[248]
+ wl0_up[247] wl0_up[246] wl0_up[245] wl0_up[244] wl0_up[243] wl0_up[242] wl0_up[241]
+ wl0_up[240] wl0_up[239] wl0_up[238] wl0_up[237] wl0_up[236] wl0_up[235] wl0_up[234]
+ wl0_up[233] wl0_up[232] wl0_up[231] wl0_up[230] wl0_up[229] wl0_up[228] wl0_up[227]
+ wl0_up[226] wl0_up[225] wl0_up[224] wl0_up[223] wl0_up[222] wl0_up[221] wl0_up[220]
+ wl0_up[219] wl0_up[218] wl0_up[217] wl0_up[216] wl0_up[215] wl0_up[214] wl0_up[213]
+ wl0_up[212] wl0_up[211] wl0_up[210] wl0_up[209] wl0_up[208] wl0_up[207] wl0_up[206]
+ wl0_up[205] wl0_up[204] wl0_up[203] wl0_up[202] wl0_up[201] wl0_up[200] wl0_up[199]
+ wl0_up[198] wl0_up[197] wl0_up[196] wl0_up[195] wl0_up[194] wl0_up[193] wl0_up[192]
+ wl0_up[191] wl0_up[190] wl0_up[189] wl0_up[188] wl0_up[187] wl0_up[186] wl0_up[185]
+ wl0_up[184] wl0_up[183] wl0_up[182] wl0_up[181] wl0_up[180] wl0_up[179] wl0_up[178]
+ wl0_up[177] wl0_up[176] wl0_up[175] wl0_up[174] wl0_up[173] wl0_up[172] wl0_up[171]
+ wl0_up[170] wl0_up[169] wl0_up[168] wl0_up[167] wl0_up[166] wl0_up[165] wl0_up[164]
+ wl0_up[163] wl0_up[162] wl0_up[161] wl0_up[160] wl0_up[159] wl0_up[158] wl0_up[157]
+ wl0_up[156] wl0_up[155] wl0_up[154] wl0_up[153] wl0_up[152] wl0_up[151] wl0_up[150]
+ wl0_up[149] wl0_up[148] wl0_up[147] wl0_up[146] wl0_up[145] wl0_up[144] wl0_up[143]
+ wl0_up[142] wl0_up[141] wl0_up[140] wl0_up[139] wl0_up[138] wl0_up[137] wl0_up[136]
+ wl0_up[135] wl0_up[134] wl0_up[133] wl0_up[132] wl0_up[131] wl0_up[130] wl0_up[129]
+ wl0_up[128] issax2dec256
Xdec1 vss vss vss hi#[7] hi#[6] hi#[5] hi#[4] hi#[3] hi#[2] hi#[1] hi#[0] mid#[7]
+ mid#[6] mid#[5] mid#[4] mid#[3] mid#[2] mid#[1] mid#[0] slpen1 vcc vss wl1_dn[127]
+ wl1_dn[126] wl1_dn[125] wl1_dn[124] wl1_dn[123] wl1_dn[122] wl1_dn[121] wl1_dn[120]
+ wl1_dn[119] wl1_dn[118] wl1_dn[117] wl1_dn[116] wl1_dn[115] wl1_dn[114] wl1_dn[113]
+ wl1_dn[112] wl1_dn[111] wl1_dn[110] wl1_dn[109] wl1_dn[108] wl1_dn[107] wl1_dn[106]
+ wl1_dn[105] wl1_dn[104] wl1_dn[103] wl1_dn[102] wl1_dn[101] wl1_dn[100] wl1_dn[99]
+ wl1_dn[98] wl1_dn[97] wl1_dn[96] wl1_dn[95] wl1_dn[94] wl1_dn[93] wl1_dn[92] wl1_dn[91]
+ wl1_dn[90] wl1_dn[89] wl1_dn[88] wl1_dn[87] wl1_dn[86] wl1_dn[85] wl1_dn[84] wl1_dn[83]
+ wl1_dn[82] wl1_dn[81] wl1_dn[80] wl1_dn[79] wl1_dn[78] wl1_dn[77] wl1_dn[76] wl1_dn[75]
+ wl1_dn[74] wl1_dn[73] wl1_dn[72] wl1_dn[71] wl1_dn[70] wl1_dn[69] wl1_dn[68] wl1_dn[67]
+ wl1_dn[66] wl1_dn[65] wl1_dn[64] wl1_dn[63] wl1_dn[62] wl1_dn[61] wl1_dn[60] wl1_dn[59]
+ wl1_dn[58] wl1_dn[57] wl1_dn[56] wl1_dn[55] wl1_dn[54] wl1_dn[53] wl1_dn[52] wl1_dn[51]
+ wl1_dn[50] wl1_dn[49] wl1_dn[48] wl1_dn[47] wl1_dn[46] wl1_dn[45] wl1_dn[44] wl1_dn[43]
+ wl1_dn[42] wl1_dn[41] wl1_dn[40] wl1_dn[39] wl1_dn[38] wl1_dn[37] wl1_dn[36] wl1_dn[35]
+ wl1_dn[34] wl1_dn[33] wl1_dn[32] wl1_dn[31] wl1_dn[30] wl1_dn[29] wl1_dn[28] wl1_dn[27]
+ wl1_dn[26] wl1_dn[25] wl1_dn[24] wl1_dn[23] wl1_dn[22] wl1_dn[21] wl1_dn[20] wl1_dn[19]
+ wl1_dn[18] wl1_dn[17] wl1_dn[16] wl1_dn[15] wl1_dn[14] wl1_dn[13] wl1_dn[12] wl1_dn[11]
+ wl1_dn[10] wl1_dn[9] wl1_dn[8] wl1_dn[7] wl1_dn[6] wl1_dn[5] wl1_dn[4] wl1_dn[3]
+ wl1_dn[2] wl1_dn[1] wl1_dn[0] wl1_dn[255] wl1_dn[254] wl1_dn[253] wl1_dn[252]
+ wl1_dn[251] wl1_dn[250] wl1_dn[249] wl1_dn[248] wl1_dn[247] wl1_dn[246] wl1_dn[245]
+ wl1_dn[244] wl1_dn[243] wl1_dn[242] wl1_dn[241] wl1_dn[240] wl1_dn[239] wl1_dn[238]
+ wl1_dn[237] wl1_dn[236] wl1_dn[235] wl1_dn[234] wl1_dn[233] wl1_dn[232] wl1_dn[231]
+ wl1_dn[230] wl1_dn[229] wl1_dn[228] wl1_dn[227] wl1_dn[226] wl1_dn[225] wl1_dn[224]
+ wl1_dn[223] wl1_dn[222] wl1_dn[221] wl1_dn[220] wl1_dn[219] wl1_dn[218] wl1_dn[217]
+ wl1_dn[216] wl1_dn[215] wl1_dn[214] wl1_dn[213] wl1_dn[212] wl1_dn[211] wl1_dn[210]
+ wl1_dn[209] wl1_dn[208] wl1_dn[207] wl1_dn[206] wl1_dn[205] wl1_dn[204] wl1_dn[203]
+ wl1_dn[202] wl1_dn[201] wl1_dn[200] wl1_dn[199] wl1_dn[198] wl1_dn[197] wl1_dn[196]
+ wl1_dn[195] wl1_dn[194] wl1_dn[193] wl1_dn[192] wl1_dn[191] wl1_dn[190] wl1_dn[189]
+ wl1_dn[188] wl1_dn[187] wl1_dn[186] wl1_dn[185] wl1_dn[184] wl1_dn[183] wl1_dn[182]
+ wl1_dn[181] wl1_dn[180] wl1_dn[179] wl1_dn[178] wl1_dn[177] wl1_dn[176] wl1_dn[175]
+ wl1_dn[174] wl1_dn[173] wl1_dn[172] wl1_dn[171] wl1_dn[170] wl1_dn[169] wl1_dn[168]
+ wl1_dn[167] wl1_dn[166] wl1_dn[165] wl1_dn[164] wl1_dn[163] wl1_dn[162] wl1_dn[161]
+ wl1_dn[160] wl1_dn[159] wl1_dn[158] wl1_dn[157] wl1_dn[156] wl1_dn[155] wl1_dn[154]
+ wl1_dn[153] wl1_dn[152] wl1_dn[151] wl1_dn[150] wl1_dn[149] wl1_dn[148] wl1_dn[147]
+ wl1_dn[146] wl1_dn[145] wl1_dn[144] wl1_dn[143] wl1_dn[142] wl1_dn[141] wl1_dn[140]
+ wl1_dn[139] wl1_dn[138] wl1_dn[137] wl1_dn[136] wl1_dn[135] wl1_dn[134] wl1_dn[133]
+ wl1_dn[132] wl1_dn[131] wl1_dn[130] wl1_dn[129] wl1_dn[128] wle1[3] wle1[2] wle1[1]
+ wle1[0] wlered1[1] wlered1[0] wllvlnn[2] wllvlnn[1] wllvlnn[0] redwl1_dn[1] redwl1_dn[0]
+ redwl1_up[1] redwl1_up[0] wl1_up[127] wl1_up[126] wl1_up[125] wl1_up[124] wl1_up[123]
+ wl1_up[122] wl1_up[121] wl1_up[120] wl1_up[119] wl1_up[118] wl1_up[117] wl1_up[116]
+ wl1_up[115] wl1_up[114] wl1_up[113] wl1_up[112] wl1_up[111] wl1_up[110] wl1_up[109]
+ wl1_up[108] wl1_up[107] wl1_up[106] wl1_up[105] wl1_up[104] wl1_up[103] wl1_up[102]
+ wl1_up[101] wl1_up[100] wl1_up[99] wl1_up[98] wl1_up[97] wl1_up[96] wl1_up[95]
+ wl1_up[94] wl1_up[93] wl1_up[92] wl1_up[91] wl1_up[90] wl1_up[89] wl1_up[88] wl1_up[87]
+ wl1_up[86] wl1_up[85] wl1_up[84] wl1_up[83] wl1_up[82] wl1_up[81] wl1_up[80] wl1_up[79]
+ wl1_up[78] wl1_up[77] wl1_up[76] wl1_up[75] wl1_up[74] wl1_up[73] wl1_up[72] wl1_up[71]
+ wl1_up[70] wl1_up[69] wl1_up[68] wl1_up[67] wl1_up[66] wl1_up[65] wl1_up[64] wl1_up[63]
+ wl1_up[62] wl1_up[61] wl1_up[60] wl1_up[59] wl1_up[58] wl1_up[57] wl1_up[56] wl1_up[55]
+ wl1_up[54] wl1_up[53] wl1_up[52] wl1_up[51] wl1_up[50] wl1_up[49] wl1_up[48] wl1_up[47]
+ wl1_up[46] wl1_up[45] wl1_up[44] wl1_up[43] wl1_up[42] wl1_up[41] wl1_up[40] wl1_up[39]
+ wl1_up[38] wl1_up[37] wl1_up[36] wl1_up[35] wl1_up[34] wl1_up[33] wl1_up[32] wl1_up[31]
+ wl1_up[30] wl1_up[29] wl1_up[28] wl1_up[27] wl1_up[26] wl1_up[25] wl1_up[24] wl1_up[23]
+ wl1_up[22] wl1_up[21] wl1_up[20] wl1_up[19] wl1_up[18] wl1_up[17] wl1_up[16] wl1_up[15]
+ wl1_up[14] wl1_up[13] wl1_up[12] wl1_up[11] wl1_up[10] wl1_up[9] wl1_up[8] wl1_up[7]
+ wl1_up[6] wl1_up[5] wl1_up[4] wl1_up[3] wl1_up[2] wl1_up[1] wl1_up[0] wl1_up[255]
+ wl1_up[254] wl1_up[253] wl1_up[252] wl1_up[251] wl1_up[250] wl1_up[249] wl1_up[248]
+ wl1_up[247] wl1_up[246] wl1_up[245] wl1_up[244] wl1_up[243] wl1_up[242] wl1_up[241]
+ wl1_up[240] wl1_up[239] wl1_up[238] wl1_up[237] wl1_up[236] wl1_up[235] wl1_up[234]
+ wl1_up[233] wl1_up[232] wl1_up[231] wl1_up[230] wl1_up[229] wl1_up[228] wl1_up[227]
+ wl1_up[226] wl1_up[225] wl1_up[224] wl1_up[223] wl1_up[222] wl1_up[221] wl1_up[220]
+ wl1_up[219] wl1_up[218] wl1_up[217] wl1_up[216] wl1_up[215] wl1_up[214] wl1_up[213]
+ wl1_up[212] wl1_up[211] wl1_up[210] wl1_up[209] wl1_up[208] wl1_up[207] wl1_up[206]
+ wl1_up[205] wl1_up[204] wl1_up[203] wl1_up[202] wl1_up[201] wl1_up[200] wl1_up[199]
+ wl1_up[198] wl1_up[197] wl1_up[196] wl1_up[195] wl1_up[194] wl1_up[193] wl1_up[192]
+ wl1_up[191] wl1_up[190] wl1_up[189] wl1_up[188] wl1_up[187] wl1_up[186] wl1_up[185]
+ wl1_up[184] wl1_up[183] wl1_up[182] wl1_up[181] wl1_up[180] wl1_up[179] wl1_up[178]
+ wl1_up[177] wl1_up[176] wl1_up[175] wl1_up[174] wl1_up[173] wl1_up[172] wl1_up[171]
+ wl1_up[170] wl1_up[169] wl1_up[168] wl1_up[167] wl1_up[166] wl1_up[165] wl1_up[164]
+ wl1_up[163] wl1_up[162] wl1_up[161] wl1_up[160] wl1_up[159] wl1_up[158] wl1_up[157]
+ wl1_up[156] wl1_up[155] wl1_up[154] wl1_up[153] wl1_up[152] wl1_up[151] wl1_up[150]
+ wl1_up[149] wl1_up[148] wl1_up[147] wl1_up[146] wl1_up[145] wl1_up[144] wl1_up[143]
+ wl1_up[142] wl1_up[141] wl1_up[140] wl1_up[139] wl1_up[138] wl1_up[137] wl1_up[136]
+ wl1_up[135] wl1_up[134] wl1_up[133] wl1_up[132] wl1_up[131] wl1_up[130] wl1_up[129]
+ wl1_up[128] issax2dec256
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice idin[0] lyaennn lyal0bl lyal0blnn
+ nbl_kicknn pcnn0 pcnn1 rddataout[0] rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0]
+ rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0] redwl0[1] redwl0[0] redwl1[1] redwl1[0]
+ saenn sapchnn vcc vss waenn[2] waenn[1] waenn[0] wl0[255] wl0[254] wl0[253] wl0[252]
+ wl0[251] wl0[250] wl0[249] wl0[248] wl0[247] wl0[246] wl0[245] wl0[244] wl0[243]
+ wl0[242] wl0[241] wl0[240] wl0[239] wl0[238] wl0[237] wl0[236] wl0[235] wl0[234]
+ wl0[233] wl0[232] wl0[231] wl0[230] wl0[229] wl0[228] wl0[227] wl0[226] wl0[225]
+ wl0[224] wl0[223] wl0[222] wl0[221] wl0[220] wl0[219] wl0[218] wl0[217] wl0[216]
+ wl0[215] wl0[214] wl0[213] wl0[212] wl0[211] wl0[210] wl0[209] wl0[208] wl0[207]
+ wl0[206] wl0[205] wl0[204] wl0[203] wl0[202] wl0[201] wl0[200] wl0[199] wl0[198]
+ wl0[197] wl0[196] wl0[195] wl0[194] wl0[193] wl0[192] wl0[191] wl0[190] wl0[189]
+ wl0[188] wl0[187] wl0[186] wl0[185] wl0[184] wl0[183] wl0[182] wl0[181] wl0[180]
+ wl0[179] wl0[178] wl0[177] wl0[176] wl0[175] wl0[174] wl0[173] wl0[172] wl0[171]
+ wl0[170] wl0[169] wl0[168] wl0[167] wl0[166] wl0[165] wl0[164] wl0[163] wl0[162]
+ wl0[161] wl0[160] wl0[159] wl0[158] wl0[157] wl0[156] wl0[155] wl0[154] wl0[153]
+ wl0[152] wl0[151] wl0[150] wl0[149] wl0[148] wl0[147] wl0[146] wl0[145] wl0[144]
+ wl0[143] wl0[142] wl0[141] wl0[140] wl0[139] wl0[138] wl0[137] wl0[136] wl0[135]
+ wl0[134] wl0[133] wl0[132] wl0[131] wl0[130] wl0[129] wl0[128] wl0[127] wl0[126]
+ wl0[125] wl0[124] wl0[123] wl0[122] wl0[121] wl0[120] wl0[119] wl0[118] wl0[117]
+ wl0[116] wl0[115] wl0[114] wl0[113] wl0[112] wl0[111] wl0[110] wl0[109] wl0[108]
+ wl0[107] wl0[106] wl0[105] wl0[104] wl0[103] wl0[102] wl0[101] wl0[100] wl0[99]
+ wl0[98] wl0[97] wl0[96] wl0[95] wl0[94] wl0[93] wl0[92] wl0[91] wl0[90] wl0[89]
+ wl0[88] wl0[87] wl0[86] wl0[85] wl0[84] wl0[83] wl0[82] wl0[81] wl0[80] wl0[79]
+ wl0[78] wl0[77] wl0[76] wl0[75] wl0[74] wl0[73] wl0[72] wl0[71] wl0[70] wl0[69]
+ wl0[68] wl0[67] wl0[66] wl0[65] wl0[64] wl0[63] wl0[62] wl0[61] wl0[60] wl0[59]
+ wl0[58] wl0[57] wl0[56] wl0[55] wl0[54] wl0[53] wl0[52] wl0[51] wl0[50] wl0[49]
+ wl0[48] wl0[47] wl0[46] wl0[45] wl0[44] wl0[43] wl0[42] wl0[41] wl0[40] wl0[39]
+ wl0[38] wl0[37] wl0[36] wl0[35] wl0[34] wl0[33] wl0[32] wl0[31] wl0[30] wl0[29]
+ wl0[28] wl0[27] wl0[26] wl0[25] wl0[24] wl0[23] wl0[22] wl0[21] wl0[20] wl0[19]
+ wl0[18] wl0[17] wl0[16] wl0[15] wl0[14] wl0[13] wl0[12] wl0[11] wl0[10] wl0[9]
+ wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3] wl0[2] wl0[1] wl0[0] wl1[255] wl1[254]
+ wl1[253] wl1[252] wl1[251] wl1[250] wl1[249] wl1[248] wl1[247] wl1[246] wl1[245]
+ wl1[244] wl1[243] wl1[242] wl1[241] wl1[240] wl1[239] wl1[238] wl1[237] wl1[236]
+ wl1[235] wl1[234] wl1[233] wl1[232] wl1[231] wl1[230] wl1[229] wl1[228] wl1[227]
+ wl1[226] wl1[225] wl1[224] wl1[223] wl1[222] wl1[221] wl1[220] wl1[219] wl1[218]
+ wl1[217] wl1[216] wl1[215] wl1[214] wl1[213] wl1[212] wl1[211] wl1[210] wl1[209]
+ wl1[208] wl1[207] wl1[206] wl1[205] wl1[204] wl1[203] wl1[202] wl1[201] wl1[200]
+ wl1[199] wl1[198] wl1[197] wl1[196] wl1[195] wl1[194] wl1[193] wl1[192] wl1[191]
+ wl1[190] wl1[189] wl1[188] wl1[187] wl1[186] wl1[185] wl1[184] wl1[183] wl1[182]
+ wl1[181] wl1[180] wl1[179] wl1[178] wl1[177] wl1[176] wl1[175] wl1[174] wl1[173]
+ wl1[172] wl1[171] wl1[170] wl1[169] wl1[168] wl1[167] wl1[166] wl1[165] wl1[164]
+ wl1[163] wl1[162] wl1[161] wl1[160] wl1[159] wl1[158] wl1[157] wl1[156] wl1[155]
+ wl1[154] wl1[153] wl1[152] wl1[151] wl1[150] wl1[149] wl1[148] wl1[147] wl1[146]
+ wl1[145] wl1[144] wl1[143] wl1[142] wl1[141] wl1[140] wl1[139] wl1[138] wl1[137]
+ wl1[136] wl1[135] wl1[134] wl1[133] wl1[132] wl1[131] wl1[130] wl1[129] wl1[128]
+ wl1[127] wl1[126] wl1[125] wl1[124] wl1[123] wl1[122] wl1[121] wl1[120] wl1[119]
+ wl1[118] wl1[117] wl1[116] wl1[115] wl1[114] wl1[113] wl1[112] wl1[111] wl1[110]
+ wl1[109] wl1[108] wl1[107] wl1[106] wl1[105] wl1[104] wl1[103] wl1[102] wl1[101]
+ wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95] wl1[94] wl1[93] wl1[92] wl1[91]
+ wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85] wl1[84] wl1[83] wl1[82] wl1[81]
+ wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75] wl1[74] wl1[73] wl1[72] wl1[71]
+ wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65] wl1[64] wl1[63] wl1[62] wl1[61]
+ wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55] wl1[54] wl1[53] wl1[52] wl1[51]
+ wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45] wl1[44] wl1[43] wl1[42] wl1[41]
+ wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35] wl1[34] wl1[33] wl1[32] wl1[31]
+ wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25] wl1[24] wl1[23] wl1[22] wl1[21]
+ wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15] wl1[14] wl1[13] wl1[12] wl1[11]
+ wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4] wl1[3] wl1[2] wl1[1] wl1[0]
+ wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0] wrcolsel1[3] wrcolsel1[2]
+ wrcolsel1[1] wrcolsel1[0] wrdataen
*.PININFO idin[0]:I lyaennn:I lyal0bl:I lyal0blnn:I nbl_kicknn:I pcnn0:I pcnn1:I rddataout[0]:O rdysel0[3]:I rdysel0[2]:I rdysel0[1]:I rdysel0[0]:I rdysel1[3]:I rdysel1[2]:I rdysel1[1]:I rdysel1[0]:I redwl0[1]:I redwl0[0]:I redwl1[1]:I redwl1[0]:I
*.PININFO saenn:I sapchnn:I vcc:I vss:I waenn[2]:I waenn[1]:I waenn[0]:I wl0[255]:I wl0[254]:I wl0[253]:I wl0[252]:I wl0[251]:I wl0[250]:I wl0[249]:I wl0[248]:I wl0[247]:I wl0[246]:I wl0[245]:I wl0[244]:I wl0[243]:I
*.PININFO wl0[242]:I wl0[241]:I wl0[240]:I wl0[239]:I wl0[238]:I wl0[237]:I wl0[236]:I wl0[235]:I wl0[234]:I wl0[233]:I wl0[232]:I wl0[231]:I wl0[230]:I wl0[229]:I wl0[228]:I wl0[227]:I wl0[226]:I wl0[225]:I wl0[224]:I wl0[223]:I
*.PININFO wl0[222]:I wl0[221]:I wl0[220]:I wl0[219]:I wl0[218]:I wl0[217]:I wl0[216]:I wl0[215]:I wl0[214]:I wl0[213]:I wl0[212]:I wl0[211]:I wl0[210]:I wl0[209]:I wl0[208]:I wl0[207]:I wl0[206]:I wl0[205]:I wl0[204]:I wl0[203]:I
*.PININFO wl0[202]:I wl0[201]:I wl0[200]:I wl0[199]:I wl0[198]:I wl0[197]:I wl0[196]:I wl0[195]:I wl0[194]:I wl0[193]:I wl0[192]:I wl0[191]:I wl0[190]:I wl0[189]:I wl0[188]:I wl0[187]:I wl0[186]:I wl0[185]:I wl0[184]:I wl0[183]:I
*.PININFO wl0[182]:I wl0[181]:I wl0[180]:I wl0[179]:I wl0[178]:I wl0[177]:I wl0[176]:I wl0[175]:I wl0[174]:I wl0[173]:I wl0[172]:I wl0[171]:I wl0[170]:I wl0[169]:I wl0[168]:I wl0[167]:I wl0[166]:I wl0[165]:I wl0[164]:I wl0[163]:I
*.PININFO wl0[162]:I wl0[161]:I wl0[160]:I wl0[159]:I wl0[158]:I wl0[157]:I wl0[156]:I wl0[155]:I wl0[154]:I wl0[153]:I wl0[152]:I wl0[151]:I wl0[150]:I wl0[149]:I wl0[148]:I wl0[147]:I wl0[146]:I wl0[145]:I wl0[144]:I wl0[143]:I
*.PININFO wl0[142]:I wl0[141]:I wl0[140]:I wl0[139]:I wl0[138]:I wl0[137]:I wl0[136]:I wl0[135]:I wl0[134]:I wl0[133]:I wl0[132]:I wl0[131]:I wl0[130]:I wl0[129]:I wl0[128]:I wl0[127]:I wl0[126]:I wl0[125]:I wl0[124]:I wl0[123]:I
*.PININFO wl0[122]:I wl0[121]:I wl0[120]:I wl0[119]:I wl0[118]:I wl0[117]:I wl0[116]:I wl0[115]:I wl0[114]:I wl0[113]:I wl0[112]:I wl0[111]:I wl0[110]:I wl0[109]:I wl0[108]:I wl0[107]:I wl0[106]:I wl0[105]:I wl0[104]:I wl0[103]:I
*.PININFO wl0[102]:I wl0[101]:I wl0[100]:I wl0[99]:I wl0[98]:I wl0[97]:I wl0[96]:I wl0[95]:I wl0[94]:I wl0[93]:I wl0[92]:I wl0[91]:I wl0[90]:I wl0[89]:I wl0[88]:I wl0[87]:I wl0[86]:I wl0[85]:I wl0[84]:I wl0[83]:I
*.PININFO wl0[82]:I wl0[81]:I wl0[80]:I wl0[79]:I wl0[78]:I wl0[77]:I wl0[76]:I wl0[75]:I wl0[74]:I wl0[73]:I wl0[72]:I wl0[71]:I wl0[70]:I wl0[69]:I wl0[68]:I wl0[67]:I wl0[66]:I wl0[65]:I wl0[64]:I wl0[63]:I
*.PININFO wl0[62]:I wl0[61]:I wl0[60]:I wl0[59]:I wl0[58]:I wl0[57]:I wl0[56]:I wl0[55]:I wl0[54]:I wl0[53]:I wl0[52]:I wl0[51]:I wl0[50]:I wl0[49]:I wl0[48]:I wl0[47]:I wl0[46]:I wl0[45]:I wl0[44]:I wl0[43]:I
*.PININFO wl0[42]:I wl0[41]:I wl0[40]:I wl0[39]:I wl0[38]:I wl0[37]:I wl0[36]:I wl0[35]:I wl0[34]:I wl0[33]:I wl0[32]:I wl0[31]:I wl0[30]:I wl0[29]:I wl0[28]:I wl0[27]:I wl0[26]:I wl0[25]:I wl0[24]:I wl0[23]:I
*.PININFO wl0[22]:I wl0[21]:I wl0[20]:I wl0[19]:I wl0[18]:I wl0[17]:I wl0[16]:I wl0[15]:I wl0[14]:I wl0[13]:I wl0[12]:I wl0[11]:I wl0[10]:I wl0[9]:I wl0[8]:I wl0[7]:I wl0[6]:I wl0[5]:I wl0[4]:I wl0[3]:I
*.PININFO wl0[2]:I wl0[1]:I wl0[0]:I wl1[255]:I wl1[254]:I wl1[253]:I wl1[252]:I wl1[251]:I wl1[250]:I wl1[249]:I wl1[248]:I wl1[247]:I wl1[246]:I wl1[245]:I wl1[244]:I wl1[243]:I wl1[242]:I wl1[241]:I wl1[240]:I wl1[239]:I
*.PININFO wl1[238]:I wl1[237]:I wl1[236]:I wl1[235]:I wl1[234]:I wl1[233]:I wl1[232]:I wl1[231]:I wl1[230]:I wl1[229]:I wl1[228]:I wl1[227]:I wl1[226]:I wl1[225]:I wl1[224]:I wl1[223]:I wl1[222]:I wl1[221]:I wl1[220]:I wl1[219]:I
*.PININFO wl1[218]:I wl1[217]:I wl1[216]:I wl1[215]:I wl1[214]:I wl1[213]:I wl1[212]:I wl1[211]:I wl1[210]:I wl1[209]:I wl1[208]:I wl1[207]:I wl1[206]:I wl1[205]:I wl1[204]:I wl1[203]:I wl1[202]:I wl1[201]:I wl1[200]:I wl1[199]:I
*.PININFO wl1[198]:I wl1[197]:I wl1[196]:I wl1[195]:I wl1[194]:I wl1[193]:I wl1[192]:I wl1[191]:I wl1[190]:I wl1[189]:I wl1[188]:I wl1[187]:I wl1[186]:I wl1[185]:I wl1[184]:I wl1[183]:I wl1[182]:I wl1[181]:I wl1[180]:I wl1[179]:I
*.PININFO wl1[178]:I wl1[177]:I wl1[176]:I wl1[175]:I wl1[174]:I wl1[173]:I wl1[172]:I wl1[171]:I wl1[170]:I wl1[169]:I wl1[168]:I wl1[167]:I wl1[166]:I wl1[165]:I wl1[164]:I wl1[163]:I wl1[162]:I wl1[161]:I wl1[160]:I wl1[159]:I
*.PININFO wl1[158]:I wl1[157]:I wl1[156]:I wl1[155]:I wl1[154]:I wl1[153]:I wl1[152]:I wl1[151]:I wl1[150]:I wl1[149]:I wl1[148]:I wl1[147]:I wl1[146]:I wl1[145]:I wl1[144]:I wl1[143]:I wl1[142]:I wl1[141]:I wl1[140]:I wl1[139]:I
*.PININFO wl1[138]:I wl1[137]:I wl1[136]:I wl1[135]:I wl1[134]:I wl1[133]:I wl1[132]:I wl1[131]:I wl1[130]:I wl1[129]:I wl1[128]:I wl1[127]:I wl1[126]:I wl1[125]:I wl1[124]:I wl1[123]:I wl1[122]:I wl1[121]:I wl1[120]:I wl1[119]:I
*.PININFO wl1[118]:I wl1[117]:I wl1[116]:I wl1[115]:I wl1[114]:I wl1[113]:I wl1[112]:I wl1[111]:I wl1[110]:I wl1[109]:I wl1[108]:I wl1[107]:I wl1[106]:I wl1[105]:I wl1[104]:I wl1[103]:I wl1[102]:I wl1[101]:I wl1[100]:I wl1[99]:I
*.PININFO wl1[98]:I wl1[97]:I wl1[96]:I wl1[95]:I wl1[94]:I wl1[93]:I wl1[92]:I wl1[91]:I wl1[90]:I wl1[89]:I wl1[88]:I wl1[87]:I wl1[86]:I wl1[85]:I wl1[84]:I wl1[83]:I wl1[82]:I wl1[81]:I wl1[80]:I wl1[79]:I
*.PININFO wl1[78]:I wl1[77]:I wl1[76]:I wl1[75]:I wl1[74]:I wl1[73]:I wl1[72]:I wl1[71]:I wl1[70]:I wl1[69]:I wl1[68]:I wl1[67]:I wl1[66]:I wl1[65]:I wl1[64]:I wl1[63]:I wl1[62]:I wl1[61]:I wl1[60]:I wl1[59]:I
*.PININFO wl1[58]:I wl1[57]:I wl1[56]:I wl1[55]:I wl1[54]:I wl1[53]:I wl1[52]:I wl1[51]:I wl1[50]:I wl1[49]:I wl1[48]:I wl1[47]:I wl1[46]:I wl1[45]:I wl1[44]:I wl1[43]:I wl1[42]:I wl1[41]:I wl1[40]:I wl1[39]:I
*.PININFO wl1[38]:I wl1[37]:I wl1[36]:I wl1[35]:I wl1[34]:I wl1[33]:I wl1[32]:I wl1[31]:I wl1[30]:I wl1[29]:I wl1[28]:I wl1[27]:I wl1[26]:I wl1[25]:I wl1[24]:I wl1[23]:I wl1[22]:I wl1[21]:I wl1[20]:I wl1[19]:I
*.PININFO wl1[18]:I wl1[17]:I wl1[16]:I wl1[15]:I wl1[14]:I wl1[13]:I wl1[12]:I wl1[11]:I wl1[10]:I wl1[9]:I wl1[8]:I wl1[7]:I wl1[6]:I wl1[5]:I wl1[4]:I wl1[3]:I wl1[2]:I wl1[1]:I wl1[0]:I wrclk:I
*.PININFO wrcolsel0[3]:I wrcolsel0[2]:I wrcolsel0[1]:I wrcolsel0[0]:I wrcolsel1[3]:I wrcolsel1[2]:I wrcolsel1[1]:I wrcolsel1[0]:I wrdataen:I
Xslice0[0] bl0[3] bl0[2] bl0[1] bl0[0] blnn0[3] blnn0[2] blnn0[1] blnn0[0] vcc vss
+ wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248] wl0[247]
+ wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239] wl0[238]
+ wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230] wl0[229]
+ wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221] wl0[220]
+ wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212] wl0[211]
+ wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203] wl0[202]
+ wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194] wl0[193]
+ wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185] wl0[184]
+ wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176] wl0[175]
+ wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167] wl0[166]
+ wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158] wl0[157]
+ wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149] wl0[148]
+ wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140] wl0[139]
+ wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131] wl0[130]
+ wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122] wl0[121]
+ wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113] wl0[112]
+ wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104] wl0[103]
+ wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94] wl0[93]
+ wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84] wl0[83]
+ wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74] wl0[73]
+ wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64] wl0[63]
+ wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54] wl0[53]
+ wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44] wl0[43]
+ wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34] wl0[33]
+ wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24] wl0[23]
+ wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14] wl0[13]
+ wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3] wl0[2]
+ wl0[1] wl0[0] redwl0[1] redwl0[0] issahccary256x4
Xsramsliceio bl0[3] bl0[2] bl0[1] bl0[0] bl1[3] bl1[2] bl1[1] bl1[0] blnn0[3] blnn0[2]
+ blnn0[1] blnn0[0] blnn1[3] blnn1[2] blnn1[1] blnn1[0] idin[0] lyaennn lyal0bl
+ lyal0blnn nbl_kicknn pcnn0 pcnn1 rddataout[0] rdysel0[3] rdysel0[2] rdysel0[1]
+ rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0] saenn sapchnn vcc vss waenn[2]
+ waenn[1] waenn[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0] wrcolsel1[3]
+ wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_sliceio
Xslice1[0] bl1[3] bl1[2] bl1[1] bl1[0] blnn1[3] blnn1[2] blnn1[1] blnn1[0] vcc vss
+ wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249] wl1[248] wl1[247]
+ wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240] wl1[239] wl1[238]
+ wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231] wl1[230] wl1[229]
+ wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222] wl1[221] wl1[220]
+ wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213] wl1[212] wl1[211]
+ wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204] wl1[203] wl1[202]
+ wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195] wl1[194] wl1[193]
+ wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186] wl1[185] wl1[184]
+ wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177] wl1[176] wl1[175]
+ wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168] wl1[167] wl1[166]
+ wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159] wl1[158] wl1[157]
+ wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150] wl1[149] wl1[148]
+ wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141] wl1[140] wl1[139]
+ wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132] wl1[131] wl1[130]
+ wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123] wl1[122] wl1[121]
+ wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114] wl1[113] wl1[112]
+ wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105] wl1[104] wl1[103]
+ wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95] wl1[94] wl1[93]
+ wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85] wl1[84] wl1[83]
+ wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75] wl1[74] wl1[73]
+ wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65] wl1[64] wl1[63]
+ wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55] wl1[54] wl1[53]
+ wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45] wl1[44] wl1[43]
+ wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35] wl1[34] wl1[33]
+ wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25] wl1[24] wl1[23]
+ wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15] wl1[14] wl1[13]
+ wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4] wl1[3] wl1[2]
+ wl1[1] wl1[0] redwl1[1] redwl1[0] issahccary256x4
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_trkfullslc clkwrsynckicknn finekick[3]
+ finekick[2] finekick[1] finekick[0] fz_synckick fz_syncrd fz_syncwr nblkick rdwl
+ rdwlclkmx rdwlpw[3] rdwlpw[2] rdwlpw[1] rdwlpw[0] redwl0[1] redwl0[0] redwl1[1]
+ redwl1[0] trkwllvlnn[2] trkwllvlnn[1] trkwllvlnn[0] vcc vss wl0[255] wl0[254]
+ wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248] wl0[247] wl0[246] wl0[245]
+ wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239] wl0[238] wl0[237] wl0[236]
+ wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230] wl0[229] wl0[228] wl0[227]
+ wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221] wl0[220] wl0[219] wl0[218]
+ wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212] wl0[211] wl0[210] wl0[209]
+ wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203] wl0[202] wl0[201] wl0[200]
+ wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194] wl0[193] wl0[192] wl0[191]
+ wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185] wl0[184] wl0[183] wl0[182]
+ wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176] wl0[175] wl0[174] wl0[173]
+ wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167] wl0[166] wl0[165] wl0[164]
+ wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158] wl0[157] wl0[156] wl0[155]
+ wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149] wl0[148] wl0[147] wl0[146]
+ wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140] wl0[139] wl0[138] wl0[137]
+ wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131] wl0[130] wl0[129] wl0[128]
+ wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122] wl0[121] wl0[120] wl0[119]
+ wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113] wl0[112] wl0[111] wl0[110]
+ wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104] wl0[103] wl0[102] wl0[101]
+ wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94] wl0[93] wl0[92] wl0[91]
+ wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84] wl0[83] wl0[82] wl0[81]
+ wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74] wl0[73] wl0[72] wl0[71]
+ wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64] wl0[63] wl0[62] wl0[61]
+ wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54] wl0[53] wl0[52] wl0[51]
+ wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44] wl0[43] wl0[42] wl0[41]
+ wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34] wl0[33] wl0[32] wl0[31]
+ wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24] wl0[23] wl0[22] wl0[21]
+ wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14] wl0[13] wl0[12] wl0[11]
+ wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3] wl0[2] wl0[1] wl0[0]
+ wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249] wl1[248] wl1[247]
+ wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240] wl1[239] wl1[238]
+ wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231] wl1[230] wl1[229]
+ wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222] wl1[221] wl1[220]
+ wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213] wl1[212] wl1[211]
+ wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204] wl1[203] wl1[202]
+ wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195] wl1[194] wl1[193]
+ wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186] wl1[185] wl1[184]
+ wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177] wl1[176] wl1[175]
+ wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168] wl1[167] wl1[166]
+ wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159] wl1[158] wl1[157]
+ wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150] wl1[149] wl1[148]
+ wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141] wl1[140] wl1[139]
+ wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132] wl1[131] wl1[130]
+ wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123] wl1[122] wl1[121]
+ wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114] wl1[113] wl1[112]
+ wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105] wl1[104] wl1[103]
+ wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95] wl1[94] wl1[93]
+ wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85] wl1[84] wl1[83]
+ wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75] wl1[74] wl1[73]
+ wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65] wl1[64] wl1[63]
+ wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55] wl1[54] wl1[53]
+ wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45] wl1[44] wl1[43]
+ wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35] wl1[34] wl1[33]
+ wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25] wl1[24] wl1[23]
+ wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15] wl1[14] wl1[13]
+ wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4] wl1[3] wl1[2]
+ wl1[1] wl1[0] wrwl wrwlclkmx wrwlpw[1] wrwlpw[0]
*.PININFO clkwrsynckicknn:I finekick[3]:I finekick[2]:I finekick[1]:I finekick[0]:I fz_synckick:I fz_syncrd:I fz_syncwr:I nblkick:O rdwl:I rdwlclkmx:O rdwlpw[3]:I rdwlpw[2]:I rdwlpw[1]:I rdwlpw[0]:I redwl0[1]:I redwl0[0]:I redwl1[1]:I redwl1[0]:I trkwllvlnn[2]:I
*.PININFO trkwllvlnn[1]:I trkwllvlnn[0]:I vcc:I vss:I wl0[255]:I wl0[254]:I wl0[253]:I wl0[252]:I wl0[251]:I wl0[250]:I wl0[249]:I wl0[248]:I wl0[247]:I wl0[246]:I wl0[245]:I wl0[244]:I wl0[243]:I wl0[242]:I wl0[241]:I wl0[240]:I
*.PININFO wl0[239]:I wl0[238]:I wl0[237]:I wl0[236]:I wl0[235]:I wl0[234]:I wl0[233]:I wl0[232]:I wl0[231]:I wl0[230]:I wl0[229]:I wl0[228]:I wl0[227]:I wl0[226]:I wl0[225]:I wl0[224]:I wl0[223]:I wl0[222]:I wl0[221]:I wl0[220]:I
*.PININFO wl0[219]:I wl0[218]:I wl0[217]:I wl0[216]:I wl0[215]:I wl0[214]:I wl0[213]:I wl0[212]:I wl0[211]:I wl0[210]:I wl0[209]:I wl0[208]:I wl0[207]:I wl0[206]:I wl0[205]:I wl0[204]:I wl0[203]:I wl0[202]:I wl0[201]:I wl0[200]:I
*.PININFO wl0[199]:I wl0[198]:I wl0[197]:I wl0[196]:I wl0[195]:I wl0[194]:I wl0[193]:I wl0[192]:I wl0[191]:I wl0[190]:I wl0[189]:I wl0[188]:I wl0[187]:I wl0[186]:I wl0[185]:I wl0[184]:I wl0[183]:I wl0[182]:I wl0[181]:I wl0[180]:I
*.PININFO wl0[179]:I wl0[178]:I wl0[177]:I wl0[176]:I wl0[175]:I wl0[174]:I wl0[173]:I wl0[172]:I wl0[171]:I wl0[170]:I wl0[169]:I wl0[168]:I wl0[167]:I wl0[166]:I wl0[165]:I wl0[164]:I wl0[163]:I wl0[162]:I wl0[161]:I wl0[160]:I
*.PININFO wl0[159]:I wl0[158]:I wl0[157]:I wl0[156]:I wl0[155]:I wl0[154]:I wl0[153]:I wl0[152]:I wl0[151]:I wl0[150]:I wl0[149]:I wl0[148]:I wl0[147]:I wl0[146]:I wl0[145]:I wl0[144]:I wl0[143]:I wl0[142]:I wl0[141]:I wl0[140]:I
*.PININFO wl0[139]:I wl0[138]:I wl0[137]:I wl0[136]:I wl0[135]:I wl0[134]:I wl0[133]:I wl0[132]:I wl0[131]:I wl0[130]:I wl0[129]:I wl0[128]:I wl0[127]:I wl0[126]:I wl0[125]:I wl0[124]:I wl0[123]:I wl0[122]:I wl0[121]:I wl0[120]:I
*.PININFO wl0[119]:I wl0[118]:I wl0[117]:I wl0[116]:I wl0[115]:I wl0[114]:I wl0[113]:I wl0[112]:I wl0[111]:I wl0[110]:I wl0[109]:I wl0[108]:I wl0[107]:I wl0[106]:I wl0[105]:I wl0[104]:I wl0[103]:I wl0[102]:I wl0[101]:I wl0[100]:I
*.PININFO wl0[99]:I wl0[98]:I wl0[97]:I wl0[96]:I wl0[95]:I wl0[94]:I wl0[93]:I wl0[92]:I wl0[91]:I wl0[90]:I wl0[89]:I wl0[88]:I wl0[87]:I wl0[86]:I wl0[85]:I wl0[84]:I wl0[83]:I wl0[82]:I wl0[81]:I wl0[80]:I
*.PININFO wl0[79]:I wl0[78]:I wl0[77]:I wl0[76]:I wl0[75]:I wl0[74]:I wl0[73]:I wl0[72]:I wl0[71]:I wl0[70]:I wl0[69]:I wl0[68]:I wl0[67]:I wl0[66]:I wl0[65]:I wl0[64]:I wl0[63]:I wl0[62]:I wl0[61]:I wl0[60]:I
*.PININFO wl0[59]:I wl0[58]:I wl0[57]:I wl0[56]:I wl0[55]:I wl0[54]:I wl0[53]:I wl0[52]:I wl0[51]:I wl0[50]:I wl0[49]:I wl0[48]:I wl0[47]:I wl0[46]:I wl0[45]:I wl0[44]:I wl0[43]:I wl0[42]:I wl0[41]:I wl0[40]:I
*.PININFO wl0[39]:I wl0[38]:I wl0[37]:I wl0[36]:I wl0[35]:I wl0[34]:I wl0[33]:I wl0[32]:I wl0[31]:I wl0[30]:I wl0[29]:I wl0[28]:I wl0[27]:I wl0[26]:I wl0[25]:I wl0[24]:I wl0[23]:I wl0[22]:I wl0[21]:I wl0[20]:I
*.PININFO wl0[19]:I wl0[18]:I wl0[17]:I wl0[16]:I wl0[15]:I wl0[14]:I wl0[13]:I wl0[12]:I wl0[11]:I wl0[10]:I wl0[9]:I wl0[8]:I wl0[7]:I wl0[6]:I wl0[5]:I wl0[4]:I wl0[3]:I wl0[2]:I wl0[1]:I wl0[0]:I
*.PININFO wl1[255]:I wl1[254]:I wl1[253]:I wl1[252]:I wl1[251]:I wl1[250]:I wl1[249]:I wl1[248]:I wl1[247]:I wl1[246]:I wl1[245]:I wl1[244]:I wl1[243]:I wl1[242]:I wl1[241]:I wl1[240]:I wl1[239]:I wl1[238]:I wl1[237]:I wl1[236]:I
*.PININFO wl1[235]:I wl1[234]:I wl1[233]:I wl1[232]:I wl1[231]:I wl1[230]:I wl1[229]:I wl1[228]:I wl1[227]:I wl1[226]:I wl1[225]:I wl1[224]:I wl1[223]:I wl1[222]:I wl1[221]:I wl1[220]:I wl1[219]:I wl1[218]:I wl1[217]:I wl1[216]:I
*.PININFO wl1[215]:I wl1[214]:I wl1[213]:I wl1[212]:I wl1[211]:I wl1[210]:I wl1[209]:I wl1[208]:I wl1[207]:I wl1[206]:I wl1[205]:I wl1[204]:I wl1[203]:I wl1[202]:I wl1[201]:I wl1[200]:I wl1[199]:I wl1[198]:I wl1[197]:I wl1[196]:I
*.PININFO wl1[195]:I wl1[194]:I wl1[193]:I wl1[192]:I wl1[191]:I wl1[190]:I wl1[189]:I wl1[188]:I wl1[187]:I wl1[186]:I wl1[185]:I wl1[184]:I wl1[183]:I wl1[182]:I wl1[181]:I wl1[180]:I wl1[179]:I wl1[178]:I wl1[177]:I wl1[176]:I
*.PININFO wl1[175]:I wl1[174]:I wl1[173]:I wl1[172]:I wl1[171]:I wl1[170]:I wl1[169]:I wl1[168]:I wl1[167]:I wl1[166]:I wl1[165]:I wl1[164]:I wl1[163]:I wl1[162]:I wl1[161]:I wl1[160]:I wl1[159]:I wl1[158]:I wl1[157]:I wl1[156]:I
*.PININFO wl1[155]:I wl1[154]:I wl1[153]:I wl1[152]:I wl1[151]:I wl1[150]:I wl1[149]:I wl1[148]:I wl1[147]:I wl1[146]:I wl1[145]:I wl1[144]:I wl1[143]:I wl1[142]:I wl1[141]:I wl1[140]:I wl1[139]:I wl1[138]:I wl1[137]:I wl1[136]:I
*.PININFO wl1[135]:I wl1[134]:I wl1[133]:I wl1[132]:I wl1[131]:I wl1[130]:I wl1[129]:I wl1[128]:I wl1[127]:I wl1[126]:I wl1[125]:I wl1[124]:I wl1[123]:I wl1[122]:I wl1[121]:I wl1[120]:I wl1[119]:I wl1[118]:I wl1[117]:I wl1[116]:I
*.PININFO wl1[115]:I wl1[114]:I wl1[113]:I wl1[112]:I wl1[111]:I wl1[110]:I wl1[109]:I wl1[108]:I wl1[107]:I wl1[106]:I wl1[105]:I wl1[104]:I wl1[103]:I wl1[102]:I wl1[101]:I wl1[100]:I wl1[99]:I wl1[98]:I wl1[97]:I wl1[96]:I
*.PININFO wl1[95]:I wl1[94]:I wl1[93]:I wl1[92]:I wl1[91]:I wl1[90]:I wl1[89]:I wl1[88]:I wl1[87]:I wl1[86]:I wl1[85]:I wl1[84]:I wl1[83]:I wl1[82]:I wl1[81]:I wl1[80]:I wl1[79]:I wl1[78]:I wl1[77]:I wl1[76]:I
*.PININFO wl1[75]:I wl1[74]:I wl1[73]:I wl1[72]:I wl1[71]:I wl1[70]:I wl1[69]:I wl1[68]:I wl1[67]:I wl1[66]:I wl1[65]:I wl1[64]:I wl1[63]:I wl1[62]:I wl1[61]:I wl1[60]:I wl1[59]:I wl1[58]:I wl1[57]:I wl1[56]:I
*.PININFO wl1[55]:I wl1[54]:I wl1[53]:I wl1[52]:I wl1[51]:I wl1[50]:I wl1[49]:I wl1[48]:I wl1[47]:I wl1[46]:I wl1[45]:I wl1[44]:I wl1[43]:I wl1[42]:I wl1[41]:I wl1[40]:I wl1[39]:I wl1[38]:I wl1[37]:I wl1[36]:I
*.PININFO wl1[35]:I wl1[34]:I wl1[33]:I wl1[32]:I wl1[31]:I wl1[30]:I wl1[29]:I wl1[28]:I wl1[27]:I wl1[26]:I wl1[25]:I wl1[24]:I wl1[23]:I wl1[22]:I wl1[21]:I wl1[20]:I wl1[19]:I wl1[18]:I wl1[17]:I wl1[16]:I
*.PININFO wl1[15]:I wl1[14]:I wl1[13]:I wl1[12]:I wl1[11]:I wl1[10]:I wl1[9]:I wl1[8]:I wl1[7]:I wl1[6]:I wl1[5]:I wl1[4]:I wl1[3]:I wl1[2]:I wl1[1]:I wl1[0]:I wrwl:I wrwlclkmx:O wrwlpw[1]:I wrwlpw[0]:I
Xitrkslc clkwrsynckicknn finekick[3] finekick[2] finekick[1] finekick[0] nblkick
+ rdwl rdwlclkmx rdwlpw[3] rdwlpw[2] rdwlpw[1] rdwlpw[0] vcc fz_synckick fz_syncrd
+ fz_syncwr trkwllvlnn[2] trkwllvlnn[1] trkwllvlnn[0] vcc vss wl0[255] wl0[254]
+ wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248] wl0[247] wl0[246] wl0[245]
+ wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239] wl0[238] wl0[237] wl0[236]
+ wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230] wl0[229] wl0[228] wl0[227]
+ wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221] wl0[220] wl0[219] wl0[218]
+ wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212] wl0[211] wl0[210] wl0[209]
+ wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203] wl0[202] wl0[201] wl0[200]
+ wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194] wl0[193] wl0[192] wl0[191]
+ wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185] wl0[184] wl0[183] wl0[182]
+ wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176] wl0[175] wl0[174] wl0[173]
+ wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167] wl0[166] wl0[165] wl0[164]
+ wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158] wl0[157] wl0[156] wl0[155]
+ wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149] wl0[148] wl0[147] wl0[146]
+ wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140] wl0[139] wl0[138] wl0[137]
+ wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131] wl0[130] wl0[129] wl0[128]
+ wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122] wl0[121] wl0[120] wl0[119]
+ wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113] wl0[112] wl0[111] wl0[110]
+ wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104] wl0[103] wl0[102] wl0[101]
+ wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94] wl0[93] wl0[92] wl0[91]
+ wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84] wl0[83] wl0[82] wl0[81]
+ wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74] wl0[73] wl0[72] wl0[71]
+ wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64] wl0[63] wl0[62] wl0[61]
+ wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54] wl0[53] wl0[52] wl0[51]
+ wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44] wl0[43] wl0[42] wl0[41]
+ wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34] wl0[33] wl0[32] wl0[31]
+ wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24] wl0[23] wl0[22] wl0[21]
+ wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14] wl0[13] wl0[12] wl0[11]
+ wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3] wl0[2] wl0[1] wl0[0]
+ redwl0[1] redwl0[0] wrwl wrwlclkmx wrwlpw[1] wrwlpw[0] issahcctrk256slc
Xdmyslice vcc vss wl1[127] wl1[126] wl1[125] wl1[124] wl1[123] wl1[122] wl1[121]
+ wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114] wl1[113] wl1[112]
+ wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105] wl1[104] wl1[103]
+ wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95] wl1[94] wl1[93]
+ wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85] wl1[84] wl1[83]
+ wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75] wl1[74] wl1[73]
+ wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65] wl1[64] wl1[63]
+ wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55] wl1[54] wl1[53]
+ wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45] wl1[44] wl1[43]
+ wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35] wl1[34] wl1[33]
+ wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25] wl1[24] wl1[23]
+ wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15] wl1[14] wl1[13]
+ wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4] wl1[3] wl1[2]
+ wl1[1] wl1[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249] wl1[248]
+ wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240] wl1[239]
+ wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231] wl1[230]
+ wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222] wl1[221]
+ wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213] wl1[212]
+ wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204] wl1[203]
+ wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195] wl1[194]
+ wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186] wl1[185]
+ wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177] wl1[176]
+ wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168] wl1[167]
+ wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159] wl1[158]
+ wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150] wl1[149]
+ wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141] wl1[140]
+ wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132] wl1[131]
+ wl1[130] wl1[129] wl1[128] redwl1[1] redwl1[0] issahccarytrkncn256x2
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_bank_dn idin1l[67] idin1l[66] idin1l[65]
+ idin1l[64] idin1l[63] idin1l[62] idin1l[61] idin1l[60] idin1l[59] idin1l[58] idin1l[57]
+ idin1l[56] idin1l[55] idin1l[54] idin1l[53] idin1l[52] idin1l[51] idin1l[50] idin1l[49]
+ idin1l[48] idin1l[47] idin1l[46] idin1l[45] idin1l[44] idin1l[43] idin1l[42] idin1l[41]
+ idin1l[40] idin1l[39] idin1l[38] idin1l[37] idin1l[36] idin1l[35] idin1l[34] idin1l[33]
+ idin1l[32] idin1l[31] idin1l[30] idin1l[29] idin1l[28] idin1l[27] idin1l[26] idin1l[25]
+ idin1l[24] idin1l[23] idin1l[22] idin1l[21] idin1l[20] idin1l[19] idin1l[18] idin1l[17]
+ idin1l[16] idin1l[15] idin1l[14] idin1l[13] idin1l[12] idin1l[11] idin1l[10] idin1l[9]
+ idin1l[8] idin1l[7] idin1l[6] idin1l[5] idin1l[4] idin1l[3] idin1l[2] idin1l[1]
+ idin1l[0] lyaennn lyal0bl[67] lyal0bl[66] lyal0bl[65] lyal0bl[64] lyal0bl[63]
+ lyal0bl[62] lyal0bl[61] lyal0bl[60] lyal0bl[59] lyal0bl[58] lyal0bl[57] lyal0bl[56]
+ lyal0bl[55] lyal0bl[54] lyal0bl[53] lyal0bl[52] lyal0bl[51] lyal0bl[50] lyal0bl[49]
+ lyal0bl[48] lyal0bl[47] lyal0bl[46] lyal0bl[45] lyal0bl[44] lyal0bl[43] lyal0bl[42]
+ lyal0bl[41] lyal0bl[40] lyal0bl[39] lyal0bl[38] lyal0bl[37] lyal0bl[36] lyal0bl[35]
+ lyal0bl[34] lyal0bl[33] lyal0bl[32] lyal0bl[31] lyal0bl[30] lyal0bl[29] lyal0bl[28]
+ lyal0bl[27] lyal0bl[26] lyal0bl[25] lyal0bl[24] lyal0bl[23] lyal0bl[22] lyal0bl[21]
+ lyal0bl[20] lyal0bl[19] lyal0bl[18] lyal0bl[17] lyal0bl[16] lyal0bl[15] lyal0bl[14]
+ lyal0bl[13] lyal0bl[12] lyal0bl[11] lyal0bl[10] lyal0bl[9] lyal0bl[8] lyal0bl[7]
+ lyal0bl[6] lyal0bl[5] lyal0bl[4] lyal0bl[3] lyal0bl[2] lyal0bl[1] lyal0bl[0] lyal0blnn[67]
+ lyal0blnn[66] lyal0blnn[65] lyal0blnn[64] lyal0blnn[63] lyal0blnn[62] lyal0blnn[61]
+ lyal0blnn[60] lyal0blnn[59] lyal0blnn[58] lyal0blnn[57] lyal0blnn[56] lyal0blnn[55]
+ lyal0blnn[54] lyal0blnn[53] lyal0blnn[52] lyal0blnn[51] lyal0blnn[50] lyal0blnn[49]
+ lyal0blnn[48] lyal0blnn[47] lyal0blnn[46] lyal0blnn[45] lyal0blnn[44] lyal0blnn[43]
+ lyal0blnn[42] lyal0blnn[41] lyal0blnn[40] lyal0blnn[39] lyal0blnn[38] lyal0blnn[37]
+ lyal0blnn[36] lyal0blnn[35] lyal0blnn[34] lyal0blnn[33] lyal0blnn[32] lyal0blnn[31]
+ lyal0blnn[30] lyal0blnn[29] lyal0blnn[28] lyal0blnn[27] lyal0blnn[26] lyal0blnn[25]
+ lyal0blnn[24] lyal0blnn[23] lyal0blnn[22] lyal0blnn[21] lyal0blnn[20] lyal0blnn[19]
+ lyal0blnn[18] lyal0blnn[17] lyal0blnn[16] lyal0blnn[15] lyal0blnn[14] lyal0blnn[13]
+ lyal0blnn[12] lyal0blnn[11] lyal0blnn[10] lyal0blnn[9] lyal0blnn[8] lyal0blnn[7]
+ lyal0blnn[6] lyal0blnn[5] lyal0blnn[4] lyal0blnn[3] lyal0blnn[2] lyal0blnn[1]
+ lyal0blnn[0] nbl_kicknn pcnn0 pcnn1 rddataout[67] rddataout[66] rddataout[65]
+ rddataout[64] rddataout[63] rddataout[62] rddataout[61] rddataout[60] rddataout[59]
+ rddataout[58] rddataout[57] rddataout[56] rddataout[55] rddataout[54] rddataout[53]
+ rddataout[52] rddataout[51] rddataout[50] rddataout[49] rddataout[48] rddataout[47]
+ rddataout[46] rddataout[45] rddataout[44] rddataout[43] rddataout[42] rddataout[41]
+ rddataout[40] rddataout[39] rddataout[38] rddataout[37] rddataout[36] rddataout[35]
+ rddataout[34] rddataout[33] rddataout[32] rddataout[31] rddataout[30] rddataout[29]
+ rddataout[28] rddataout[27] rddataout[26] rddataout[25] rddataout[24] rddataout[23]
+ rddataout[22] rddataout[21] rddataout[20] rddataout[19] rddataout[18] rddataout[17]
+ rddataout[16] rddataout[15] rddataout[14] rddataout[13] rddataout[12] rddataout[11]
+ rddataout[10] rddataout[9] rddataout[8] rddataout[7] rddataout[6] rddataout[5]
+ rddataout[4] rddataout[3] rddataout[2] rddataout[1] rddataout[0] rdysel0[3] rdysel0[2]
+ rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0] redwl0[1] redwl0[0]
+ redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1] waenn[0] wl0[255]
+ wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248] wl0[247] wl0[246]
+ wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239] wl0[238] wl0[237]
+ wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230] wl0[229] wl0[228]
+ wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221] wl0[220] wl0[219]
+ wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212] wl0[211] wl0[210]
+ wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203] wl0[202] wl0[201]
+ wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194] wl0[193] wl0[192]
+ wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185] wl0[184] wl0[183]
+ wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176] wl0[175] wl0[174]
+ wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167] wl0[166] wl0[165]
+ wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158] wl0[157] wl0[156]
+ wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149] wl0[148] wl0[147]
+ wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140] wl0[139] wl0[138]
+ wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131] wl0[130] wl0[129]
+ wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122] wl0[121] wl0[120]
+ wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113] wl0[112] wl0[111]
+ wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104] wl0[103] wl0[102]
+ wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94] wl0[93] wl0[92]
+ wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84] wl0[83] wl0[82]
+ wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74] wl0[73] wl0[72]
+ wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64] wl0[63] wl0[62]
+ wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54] wl0[53] wl0[52]
+ wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44] wl0[43] wl0[42]
+ wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34] wl0[33] wl0[32]
+ wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24] wl0[23] wl0[22]
+ wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14] wl0[13] wl0[12]
+ wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3] wl0[2] wl0[1]
+ wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249] wl1[248]
+ wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240] wl1[239]
+ wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231] wl1[230]
+ wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222] wl1[221]
+ wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213] wl1[212]
+ wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204] wl1[203]
+ wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195] wl1[194]
+ wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186] wl1[185]
+ wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177] wl1[176]
+ wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168] wl1[167]
+ wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159] wl1[158]
+ wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150] wl1[149]
+ wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141] wl1[140]
+ wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132] wl1[131]
+ wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123] wl1[122]
+ wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114] wl1[113]
+ wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105] wl1[104]
+ wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95] wl1[94]
+ wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85] wl1[84]
+ wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75] wl1[74]
+ wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65] wl1[64]
+ wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55] wl1[54]
+ wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45] wl1[44]
+ wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35] wl1[34]
+ wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25] wl1[24]
+ wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15] wl1[14]
+ wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4] wl1[3]
+ wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen
*.PININFO idin1l[67]:I idin1l[66]:I idin1l[65]:I idin1l[64]:I idin1l[63]:I idin1l[62]:I idin1l[61]:I idin1l[60]:I idin1l[59]:I idin1l[58]:I idin1l[57]:I idin1l[56]:I idin1l[55]:I idin1l[54]:I idin1l[53]:I idin1l[52]:I idin1l[51]:I idin1l[50]:I idin1l[49]:I idin1l[48]:I
*.PININFO idin1l[47]:I idin1l[46]:I idin1l[45]:I idin1l[44]:I idin1l[43]:I idin1l[42]:I idin1l[41]:I idin1l[40]:I idin1l[39]:I idin1l[38]:I idin1l[37]:I idin1l[36]:I idin1l[35]:I idin1l[34]:I idin1l[33]:I idin1l[32]:I idin1l[31]:I idin1l[30]:I idin1l[29]:I idin1l[28]:I
*.PININFO idin1l[27]:I idin1l[26]:I idin1l[25]:I idin1l[24]:I idin1l[23]:I idin1l[22]:I idin1l[21]:I idin1l[20]:I idin1l[19]:I idin1l[18]:I idin1l[17]:I idin1l[16]:I idin1l[15]:I idin1l[14]:I idin1l[13]:I idin1l[12]:I idin1l[11]:I idin1l[10]:I idin1l[9]:I idin1l[8]:I
*.PININFO idin1l[7]:I idin1l[6]:I idin1l[5]:I idin1l[4]:I idin1l[3]:I idin1l[2]:I idin1l[1]:I idin1l[0]:I lyaennn:I lyal0bl[67]:I lyal0bl[66]:I lyal0bl[65]:I lyal0bl[64]:I lyal0bl[63]:I lyal0bl[62]:I lyal0bl[61]:I lyal0bl[60]:I lyal0bl[59]:I lyal0bl[58]:I lyal0bl[57]:I
*.PININFO lyal0bl[56]:I lyal0bl[55]:I lyal0bl[54]:I lyal0bl[53]:I lyal0bl[52]:I lyal0bl[51]:I lyal0bl[50]:I lyal0bl[49]:I lyal0bl[48]:I lyal0bl[47]:I lyal0bl[46]:I lyal0bl[45]:I lyal0bl[44]:I lyal0bl[43]:I lyal0bl[42]:I lyal0bl[41]:I lyal0bl[40]:I lyal0bl[39]:I lyal0bl[38]:I lyal0bl[37]:I
*.PININFO lyal0bl[36]:I lyal0bl[35]:I lyal0bl[34]:I lyal0bl[33]:I lyal0bl[32]:I lyal0bl[31]:I lyal0bl[30]:I lyal0bl[29]:I lyal0bl[28]:I lyal0bl[27]:I lyal0bl[26]:I lyal0bl[25]:I lyal0bl[24]:I lyal0bl[23]:I lyal0bl[22]:I lyal0bl[21]:I lyal0bl[20]:I lyal0bl[19]:I lyal0bl[18]:I lyal0bl[17]:I
*.PININFO lyal0bl[16]:I lyal0bl[15]:I lyal0bl[14]:I lyal0bl[13]:I lyal0bl[12]:I lyal0bl[11]:I lyal0bl[10]:I lyal0bl[9]:I lyal0bl[8]:I lyal0bl[7]:I lyal0bl[6]:I lyal0bl[5]:I lyal0bl[4]:I lyal0bl[3]:I lyal0bl[2]:I lyal0bl[1]:I lyal0bl[0]:I lyal0blnn[67]:I lyal0blnn[66]:I lyal0blnn[65]:I
*.PININFO lyal0blnn[64]:I lyal0blnn[63]:I lyal0blnn[62]:I lyal0blnn[61]:I lyal0blnn[60]:I lyal0blnn[59]:I lyal0blnn[58]:I lyal0blnn[57]:I lyal0blnn[56]:I lyal0blnn[55]:I lyal0blnn[54]:I lyal0blnn[53]:I lyal0blnn[52]:I lyal0blnn[51]:I lyal0blnn[50]:I lyal0blnn[49]:I lyal0blnn[48]:I lyal0blnn[47]:I lyal0blnn[46]:I lyal0blnn[45]:I
*.PININFO lyal0blnn[44]:I lyal0blnn[43]:I lyal0blnn[42]:I lyal0blnn[41]:I lyal0blnn[40]:I lyal0blnn[39]:I lyal0blnn[38]:I lyal0blnn[37]:I lyal0blnn[36]:I lyal0blnn[35]:I lyal0blnn[34]:I lyal0blnn[33]:I lyal0blnn[32]:I lyal0blnn[31]:I lyal0blnn[30]:I lyal0blnn[29]:I lyal0blnn[28]:I lyal0blnn[27]:I lyal0blnn[26]:I lyal0blnn[25]:I
*.PININFO lyal0blnn[24]:I lyal0blnn[23]:I lyal0blnn[22]:I lyal0blnn[21]:I lyal0blnn[20]:I lyal0blnn[19]:I lyal0blnn[18]:I lyal0blnn[17]:I lyal0blnn[16]:I lyal0blnn[15]:I lyal0blnn[14]:I lyal0blnn[13]:I lyal0blnn[12]:I lyal0blnn[11]:I lyal0blnn[10]:I lyal0blnn[9]:I lyal0blnn[8]:I lyal0blnn[7]:I lyal0blnn[6]:I lyal0blnn[5]:I
*.PININFO lyal0blnn[4]:I lyal0blnn[3]:I lyal0blnn[2]:I lyal0blnn[1]:I lyal0blnn[0]:I nbl_kicknn:I pcnn0:I pcnn1:I rddataout[67]:O rddataout[66]:O rddataout[65]:O rddataout[64]:O rddataout[63]:O rddataout[62]:O rddataout[61]:O rddataout[60]:O rddataout[59]:O rddataout[58]:O rddataout[57]:O rddataout[56]:O
*.PININFO rddataout[55]:O rddataout[54]:O rddataout[53]:O rddataout[52]:O rddataout[51]:O rddataout[50]:O rddataout[49]:O rddataout[48]:O rddataout[47]:O rddataout[46]:O rddataout[45]:O rddataout[44]:O rddataout[43]:O rddataout[42]:O rddataout[41]:O rddataout[40]:O rddataout[39]:O rddataout[38]:O rddataout[37]:O rddataout[36]:O
*.PININFO rddataout[35]:O rddataout[34]:O rddataout[33]:O rddataout[32]:O rddataout[31]:O rddataout[30]:O rddataout[29]:O rddataout[28]:O rddataout[27]:O rddataout[26]:O rddataout[25]:O rddataout[24]:O rddataout[23]:O rddataout[22]:O rddataout[21]:O rddataout[20]:O rddataout[19]:O rddataout[18]:O rddataout[17]:O rddataout[16]:O
*.PININFO rddataout[15]:O rddataout[14]:O rddataout[13]:O rddataout[12]:O rddataout[11]:O rddataout[10]:O rddataout[9]:O rddataout[8]:O rddataout[7]:O rddataout[6]:O rddataout[5]:O rddataout[4]:O rddataout[3]:O rddataout[2]:O rddataout[1]:O rddataout[0]:O rdysel0[3]:I rdysel0[2]:I rdysel0[1]:I rdysel0[0]:I
*.PININFO rdysel1[3]:I rdysel1[2]:I rdysel1[1]:I rdysel1[0]:I redwl0[1]:I redwl0[0]:I redwl1[1]:I redwl1[0]:I saenn:I sapchnn:I vcc:I vss:I waenn[2]:I waenn[1]:I waenn[0]:I wl0[255]:I wl0[254]:I wl0[253]:I wl0[252]:I wl0[251]:I
*.PININFO wl0[250]:I wl0[249]:I wl0[248]:I wl0[247]:I wl0[246]:I wl0[245]:I wl0[244]:I wl0[243]:I wl0[242]:I wl0[241]:I wl0[240]:I wl0[239]:I wl0[238]:I wl0[237]:I wl0[236]:I wl0[235]:I wl0[234]:I wl0[233]:I wl0[232]:I wl0[231]:I
*.PININFO wl0[230]:I wl0[229]:I wl0[228]:I wl0[227]:I wl0[226]:I wl0[225]:I wl0[224]:I wl0[223]:I wl0[222]:I wl0[221]:I wl0[220]:I wl0[219]:I wl0[218]:I wl0[217]:I wl0[216]:I wl0[215]:I wl0[214]:I wl0[213]:I wl0[212]:I wl0[211]:I
*.PININFO wl0[210]:I wl0[209]:I wl0[208]:I wl0[207]:I wl0[206]:I wl0[205]:I wl0[204]:I wl0[203]:I wl0[202]:I wl0[201]:I wl0[200]:I wl0[199]:I wl0[198]:I wl0[197]:I wl0[196]:I wl0[195]:I wl0[194]:I wl0[193]:I wl0[192]:I wl0[191]:I
*.PININFO wl0[190]:I wl0[189]:I wl0[188]:I wl0[187]:I wl0[186]:I wl0[185]:I wl0[184]:I wl0[183]:I wl0[182]:I wl0[181]:I wl0[180]:I wl0[179]:I wl0[178]:I wl0[177]:I wl0[176]:I wl0[175]:I wl0[174]:I wl0[173]:I wl0[172]:I wl0[171]:I
*.PININFO wl0[170]:I wl0[169]:I wl0[168]:I wl0[167]:I wl0[166]:I wl0[165]:I wl0[164]:I wl0[163]:I wl0[162]:I wl0[161]:I wl0[160]:I wl0[159]:I wl0[158]:I wl0[157]:I wl0[156]:I wl0[155]:I wl0[154]:I wl0[153]:I wl0[152]:I wl0[151]:I
*.PININFO wl0[150]:I wl0[149]:I wl0[148]:I wl0[147]:I wl0[146]:I wl0[145]:I wl0[144]:I wl0[143]:I wl0[142]:I wl0[141]:I wl0[140]:I wl0[139]:I wl0[138]:I wl0[137]:I wl0[136]:I wl0[135]:I wl0[134]:I wl0[133]:I wl0[132]:I wl0[131]:I
*.PININFO wl0[130]:I wl0[129]:I wl0[128]:I wl0[127]:I wl0[126]:I wl0[125]:I wl0[124]:I wl0[123]:I wl0[122]:I wl0[121]:I wl0[120]:I wl0[119]:I wl0[118]:I wl0[117]:I wl0[116]:I wl0[115]:I wl0[114]:I wl0[113]:I wl0[112]:I wl0[111]:I
*.PININFO wl0[110]:I wl0[109]:I wl0[108]:I wl0[107]:I wl0[106]:I wl0[105]:I wl0[104]:I wl0[103]:I wl0[102]:I wl0[101]:I wl0[100]:I wl0[99]:I wl0[98]:I wl0[97]:I wl0[96]:I wl0[95]:I wl0[94]:I wl0[93]:I wl0[92]:I wl0[91]:I
*.PININFO wl0[90]:I wl0[89]:I wl0[88]:I wl0[87]:I wl0[86]:I wl0[85]:I wl0[84]:I wl0[83]:I wl0[82]:I wl0[81]:I wl0[80]:I wl0[79]:I wl0[78]:I wl0[77]:I wl0[76]:I wl0[75]:I wl0[74]:I wl0[73]:I wl0[72]:I wl0[71]:I
*.PININFO wl0[70]:I wl0[69]:I wl0[68]:I wl0[67]:I wl0[66]:I wl0[65]:I wl0[64]:I wl0[63]:I wl0[62]:I wl0[61]:I wl0[60]:I wl0[59]:I wl0[58]:I wl0[57]:I wl0[56]:I wl0[55]:I wl0[54]:I wl0[53]:I wl0[52]:I wl0[51]:I
*.PININFO wl0[50]:I wl0[49]:I wl0[48]:I wl0[47]:I wl0[46]:I wl0[45]:I wl0[44]:I wl0[43]:I wl0[42]:I wl0[41]:I wl0[40]:I wl0[39]:I wl0[38]:I wl0[37]:I wl0[36]:I wl0[35]:I wl0[34]:I wl0[33]:I wl0[32]:I wl0[31]:I
*.PININFO wl0[30]:I wl0[29]:I wl0[28]:I wl0[27]:I wl0[26]:I wl0[25]:I wl0[24]:I wl0[23]:I wl0[22]:I wl0[21]:I wl0[20]:I wl0[19]:I wl0[18]:I wl0[17]:I wl0[16]:I wl0[15]:I wl0[14]:I wl0[13]:I wl0[12]:I wl0[11]:I
*.PININFO wl0[10]:I wl0[9]:I wl0[8]:I wl0[7]:I wl0[6]:I wl0[5]:I wl0[4]:I wl0[3]:I wl0[2]:I wl0[1]:I wl0[0]:I wl1[255]:I wl1[254]:I wl1[253]:I wl1[252]:I wl1[251]:I wl1[250]:I wl1[249]:I wl1[248]:I wl1[247]:I
*.PININFO wl1[246]:I wl1[245]:I wl1[244]:I wl1[243]:I wl1[242]:I wl1[241]:I wl1[240]:I wl1[239]:I wl1[238]:I wl1[237]:I wl1[236]:I wl1[235]:I wl1[234]:I wl1[233]:I wl1[232]:I wl1[231]:I wl1[230]:I wl1[229]:I wl1[228]:I wl1[227]:I
*.PININFO wl1[226]:I wl1[225]:I wl1[224]:I wl1[223]:I wl1[222]:I wl1[221]:I wl1[220]:I wl1[219]:I wl1[218]:I wl1[217]:I wl1[216]:I wl1[215]:I wl1[214]:I wl1[213]:I wl1[212]:I wl1[211]:I wl1[210]:I wl1[209]:I wl1[208]:I wl1[207]:I
*.PININFO wl1[206]:I wl1[205]:I wl1[204]:I wl1[203]:I wl1[202]:I wl1[201]:I wl1[200]:I wl1[199]:I wl1[198]:I wl1[197]:I wl1[196]:I wl1[195]:I wl1[194]:I wl1[193]:I wl1[192]:I wl1[191]:I wl1[190]:I wl1[189]:I wl1[188]:I wl1[187]:I
*.PININFO wl1[186]:I wl1[185]:I wl1[184]:I wl1[183]:I wl1[182]:I wl1[181]:I wl1[180]:I wl1[179]:I wl1[178]:I wl1[177]:I wl1[176]:I wl1[175]:I wl1[174]:I wl1[173]:I wl1[172]:I wl1[171]:I wl1[170]:I wl1[169]:I wl1[168]:I wl1[167]:I
*.PININFO wl1[166]:I wl1[165]:I wl1[164]:I wl1[163]:I wl1[162]:I wl1[161]:I wl1[160]:I wl1[159]:I wl1[158]:I wl1[157]:I wl1[156]:I wl1[155]:I wl1[154]:I wl1[153]:I wl1[152]:I wl1[151]:I wl1[150]:I wl1[149]:I wl1[148]:I wl1[147]:I
*.PININFO wl1[146]:I wl1[145]:I wl1[144]:I wl1[143]:I wl1[142]:I wl1[141]:I wl1[140]:I wl1[139]:I wl1[138]:I wl1[137]:I wl1[136]:I wl1[135]:I wl1[134]:I wl1[133]:I wl1[132]:I wl1[131]:I wl1[130]:I wl1[129]:I wl1[128]:I wl1[127]:I
*.PININFO wl1[126]:I wl1[125]:I wl1[124]:I wl1[123]:I wl1[122]:I wl1[121]:I wl1[120]:I wl1[119]:I wl1[118]:I wl1[117]:I wl1[116]:I wl1[115]:I wl1[114]:I wl1[113]:I wl1[112]:I wl1[111]:I wl1[110]:I wl1[109]:I wl1[108]:I wl1[107]:I
*.PININFO wl1[106]:I wl1[105]:I wl1[104]:I wl1[103]:I wl1[102]:I wl1[101]:I wl1[100]:I wl1[99]:I wl1[98]:I wl1[97]:I wl1[96]:I wl1[95]:I wl1[94]:I wl1[93]:I wl1[92]:I wl1[91]:I wl1[90]:I wl1[89]:I wl1[88]:I wl1[87]:I
*.PININFO wl1[86]:I wl1[85]:I wl1[84]:I wl1[83]:I wl1[82]:I wl1[81]:I wl1[80]:I wl1[79]:I wl1[78]:I wl1[77]:I wl1[76]:I wl1[75]:I wl1[74]:I wl1[73]:I wl1[72]:I wl1[71]:I wl1[70]:I wl1[69]:I wl1[68]:I wl1[67]:I
*.PININFO wl1[66]:I wl1[65]:I wl1[64]:I wl1[63]:I wl1[62]:I wl1[61]:I wl1[60]:I wl1[59]:I wl1[58]:I wl1[57]:I wl1[56]:I wl1[55]:I wl1[54]:I wl1[53]:I wl1[52]:I wl1[51]:I wl1[50]:I wl1[49]:I wl1[48]:I wl1[47]:I
*.PININFO wl1[46]:I wl1[45]:I wl1[44]:I wl1[43]:I wl1[42]:I wl1[41]:I wl1[40]:I wl1[39]:I wl1[38]:I wl1[37]:I wl1[36]:I wl1[35]:I wl1[34]:I wl1[33]:I wl1[32]:I wl1[31]:I wl1[30]:I wl1[29]:I wl1[28]:I wl1[27]:I
*.PININFO wl1[26]:I wl1[25]:I wl1[24]:I wl1[23]:I wl1[22]:I wl1[21]:I wl1[20]:I wl1[19]:I wl1[18]:I wl1[17]:I wl1[16]:I wl1[15]:I wl1[14]:I wl1[13]:I wl1[12]:I wl1[11]:I wl1[10]:I wl1[9]:I wl1[8]:I wl1[7]:I
*.PININFO wl1[6]:I wl1[5]:I wl1[4]:I wl1[3]:I wl1[2]:I wl1[1]:I wl1[0]:I wrclk:I wrcolsel0[3]:I wrcolsel0[2]:I wrcolsel0[1]:I wrcolsel0[0]:I wrcolsel1[3]:I wrcolsel1[2]:I wrcolsel1[1]:I wrcolsel1[0]:I wrdataen:I
Xslice[67] idin1l[67] lyaennn lyal0bl[67] lyal0blnn[67] nbl_kicknn pcnn0 pcnn1 rddataout[67]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[66] idin1l[66] lyaennn lyal0bl[66] lyal0blnn[66] nbl_kicknn pcnn0 pcnn1 rddataout[66]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[65] idin1l[65] lyaennn lyal0bl[65] lyal0blnn[65] nbl_kicknn pcnn0 pcnn1 rddataout[65]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[64] idin1l[64] lyaennn lyal0bl[64] lyal0blnn[64] nbl_kicknn pcnn0 pcnn1 rddataout[64]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[63] idin1l[63] lyaennn lyal0bl[63] lyal0blnn[63] nbl_kicknn pcnn0 pcnn1 rddataout[63]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[62] idin1l[62] lyaennn lyal0bl[62] lyal0blnn[62] nbl_kicknn pcnn0 pcnn1 rddataout[62]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[61] idin1l[61] lyaennn lyal0bl[61] lyal0blnn[61] nbl_kicknn pcnn0 pcnn1 rddataout[61]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[60] idin1l[60] lyaennn lyal0bl[60] lyal0blnn[60] nbl_kicknn pcnn0 pcnn1 rddataout[60]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[59] idin1l[59] lyaennn lyal0bl[59] lyal0blnn[59] nbl_kicknn pcnn0 pcnn1 rddataout[59]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[58] idin1l[58] lyaennn lyal0bl[58] lyal0blnn[58] nbl_kicknn pcnn0 pcnn1 rddataout[58]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[57] idin1l[57] lyaennn lyal0bl[57] lyal0blnn[57] nbl_kicknn pcnn0 pcnn1 rddataout[57]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[56] idin1l[56] lyaennn lyal0bl[56] lyal0blnn[56] nbl_kicknn pcnn0 pcnn1 rddataout[56]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[55] idin1l[55] lyaennn lyal0bl[55] lyal0blnn[55] nbl_kicknn pcnn0 pcnn1 rddataout[55]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[54] idin1l[54] lyaennn lyal0bl[54] lyal0blnn[54] nbl_kicknn pcnn0 pcnn1 rddataout[54]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[53] idin1l[53] lyaennn lyal0bl[53] lyal0blnn[53] nbl_kicknn pcnn0 pcnn1 rddataout[53]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[52] idin1l[52] lyaennn lyal0bl[52] lyal0blnn[52] nbl_kicknn pcnn0 pcnn1 rddataout[52]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[51] idin1l[51] lyaennn lyal0bl[51] lyal0blnn[51] nbl_kicknn pcnn0 pcnn1 rddataout[51]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[50] idin1l[50] lyaennn lyal0bl[50] lyal0blnn[50] nbl_kicknn pcnn0 pcnn1 rddataout[50]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[49] idin1l[49] lyaennn lyal0bl[49] lyal0blnn[49] nbl_kicknn pcnn0 pcnn1 rddataout[49]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[48] idin1l[48] lyaennn lyal0bl[48] lyal0blnn[48] nbl_kicknn pcnn0 pcnn1 rddataout[48]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[47] idin1l[47] lyaennn lyal0bl[47] lyal0blnn[47] nbl_kicknn pcnn0 pcnn1 rddataout[47]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[46] idin1l[46] lyaennn lyal0bl[46] lyal0blnn[46] nbl_kicknn pcnn0 pcnn1 rddataout[46]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[45] idin1l[45] lyaennn lyal0bl[45] lyal0blnn[45] nbl_kicknn pcnn0 pcnn1 rddataout[45]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[44] idin1l[44] lyaennn lyal0bl[44] lyal0blnn[44] nbl_kicknn pcnn0 pcnn1 rddataout[44]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[43] idin1l[43] lyaennn lyal0bl[43] lyal0blnn[43] nbl_kicknn pcnn0 pcnn1 rddataout[43]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[42] idin1l[42] lyaennn lyal0bl[42] lyal0blnn[42] nbl_kicknn pcnn0 pcnn1 rddataout[42]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[41] idin1l[41] lyaennn lyal0bl[41] lyal0blnn[41] nbl_kicknn pcnn0 pcnn1 rddataout[41]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[40] idin1l[40] lyaennn lyal0bl[40] lyal0blnn[40] nbl_kicknn pcnn0 pcnn1 rddataout[40]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[39] idin1l[39] lyaennn lyal0bl[39] lyal0blnn[39] nbl_kicknn pcnn0 pcnn1 rddataout[39]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[38] idin1l[38] lyaennn lyal0bl[38] lyal0blnn[38] nbl_kicknn pcnn0 pcnn1 rddataout[38]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[37] idin1l[37] lyaennn lyal0bl[37] lyal0blnn[37] nbl_kicknn pcnn0 pcnn1 rddataout[37]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[36] idin1l[36] lyaennn lyal0bl[36] lyal0blnn[36] nbl_kicknn pcnn0 pcnn1 rddataout[36]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[35] idin1l[35] lyaennn lyal0bl[35] lyal0blnn[35] nbl_kicknn pcnn0 pcnn1 rddataout[35]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[34] idin1l[34] lyaennn lyal0bl[34] lyal0blnn[34] nbl_kicknn pcnn0 pcnn1 rddataout[34]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[33] idin1l[33] lyaennn lyal0bl[33] lyal0blnn[33] nbl_kicknn pcnn0 pcnn1 rddataout[33]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[32] idin1l[32] lyaennn lyal0bl[32] lyal0blnn[32] nbl_kicknn pcnn0 pcnn1 rddataout[32]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[31] idin1l[31] lyaennn lyal0bl[31] lyal0blnn[31] nbl_kicknn pcnn0 pcnn1 rddataout[31]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[30] idin1l[30] lyaennn lyal0bl[30] lyal0blnn[30] nbl_kicknn pcnn0 pcnn1 rddataout[30]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[29] idin1l[29] lyaennn lyal0bl[29] lyal0blnn[29] nbl_kicknn pcnn0 pcnn1 rddataout[29]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[28] idin1l[28] lyaennn lyal0bl[28] lyal0blnn[28] nbl_kicknn pcnn0 pcnn1 rddataout[28]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[27] idin1l[27] lyaennn lyal0bl[27] lyal0blnn[27] nbl_kicknn pcnn0 pcnn1 rddataout[27]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[26] idin1l[26] lyaennn lyal0bl[26] lyal0blnn[26] nbl_kicknn pcnn0 pcnn1 rddataout[26]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[25] idin1l[25] lyaennn lyal0bl[25] lyal0blnn[25] nbl_kicknn pcnn0 pcnn1 rddataout[25]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[24] idin1l[24] lyaennn lyal0bl[24] lyal0blnn[24] nbl_kicknn pcnn0 pcnn1 rddataout[24]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[23] idin1l[23] lyaennn lyal0bl[23] lyal0blnn[23] nbl_kicknn pcnn0 pcnn1 rddataout[23]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[22] idin1l[22] lyaennn lyal0bl[22] lyal0blnn[22] nbl_kicknn pcnn0 pcnn1 rddataout[22]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[21] idin1l[21] lyaennn lyal0bl[21] lyal0blnn[21] nbl_kicknn pcnn0 pcnn1 rddataout[21]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[20] idin1l[20] lyaennn lyal0bl[20] lyal0blnn[20] nbl_kicknn pcnn0 pcnn1 rddataout[20]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[19] idin1l[19] lyaennn lyal0bl[19] lyal0blnn[19] nbl_kicknn pcnn0 pcnn1 rddataout[19]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[18] idin1l[18] lyaennn lyal0bl[18] lyal0blnn[18] nbl_kicknn pcnn0 pcnn1 rddataout[18]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[17] idin1l[17] lyaennn lyal0bl[17] lyal0blnn[17] nbl_kicknn pcnn0 pcnn1 rddataout[17]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[16] idin1l[16] lyaennn lyal0bl[16] lyal0blnn[16] nbl_kicknn pcnn0 pcnn1 rddataout[16]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[15] idin1l[15] lyaennn lyal0bl[15] lyal0blnn[15] nbl_kicknn pcnn0 pcnn1 rddataout[15]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[14] idin1l[14] lyaennn lyal0bl[14] lyal0blnn[14] nbl_kicknn pcnn0 pcnn1 rddataout[14]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[13] idin1l[13] lyaennn lyal0bl[13] lyal0blnn[13] nbl_kicknn pcnn0 pcnn1 rddataout[13]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[12] idin1l[12] lyaennn lyal0bl[12] lyal0blnn[12] nbl_kicknn pcnn0 pcnn1 rddataout[12]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[11] idin1l[11] lyaennn lyal0bl[11] lyal0blnn[11] nbl_kicknn pcnn0 pcnn1 rddataout[11]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[10] idin1l[10] lyaennn lyal0bl[10] lyal0blnn[10] nbl_kicknn pcnn0 pcnn1 rddataout[10]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[9] idin1l[9] lyaennn lyal0bl[9] lyal0blnn[9] nbl_kicknn pcnn0 pcnn1 rddataout[9]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[8] idin1l[8] lyaennn lyal0bl[8] lyal0blnn[8] nbl_kicknn pcnn0 pcnn1 rddataout[8]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[7] idin1l[7] lyaennn lyal0bl[7] lyal0blnn[7] nbl_kicknn pcnn0 pcnn1 rddataout[7]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[6] idin1l[6] lyaennn lyal0bl[6] lyal0blnn[6] nbl_kicknn pcnn0 pcnn1 rddataout[6]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[5] idin1l[5] lyaennn lyal0bl[5] lyal0blnn[5] nbl_kicknn pcnn0 pcnn1 rddataout[5]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[4] idin1l[4] lyaennn lyal0bl[4] lyal0blnn[4] nbl_kicknn pcnn0 pcnn1 rddataout[4]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[3] idin1l[3] lyaennn lyal0bl[3] lyal0blnn[3] nbl_kicknn pcnn0 pcnn1 rddataout[3]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[2] idin1l[2] lyaennn lyal0bl[2] lyal0blnn[2] nbl_kicknn pcnn0 pcnn1 rddataout[2]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[1] idin1l[1] lyaennn lyal0bl[1] lyal0blnn[1] nbl_kicknn pcnn0 pcnn1 rddataout[1]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[0] idin1l[0] lyaennn lyal0bl[0] lyal0blnn[0] nbl_kicknn pcnn0 pcnn1 rddataout[0]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_bank_up idin1l[66] idin1l[65] idin1l[64]
+ idin1l[63] idin1l[62] idin1l[61] idin1l[60] idin1l[59] idin1l[58] idin1l[57] idin1l[56]
+ idin1l[55] idin1l[54] idin1l[53] idin1l[52] idin1l[51] idin1l[50] idin1l[49] idin1l[48]
+ idin1l[47] idin1l[46] idin1l[45] idin1l[44] idin1l[43] idin1l[42] idin1l[41] idin1l[40]
+ idin1l[39] idin1l[38] idin1l[37] idin1l[36] idin1l[35] idin1l[34] idin1l[33] idin1l[32]
+ idin1l[31] idin1l[30] idin1l[29] idin1l[28] idin1l[27] idin1l[26] idin1l[25] idin1l[24]
+ idin1l[23] idin1l[22] idin1l[21] idin1l[20] idin1l[19] idin1l[18] idin1l[17] idin1l[16]
+ idin1l[15] idin1l[14] idin1l[13] idin1l[12] idin1l[11] idin1l[10] idin1l[9] idin1l[8]
+ idin1l[7] idin1l[6] idin1l[5] idin1l[4] idin1l[3] idin1l[2] idin1l[1] idin1l[0]
+ lyaennn lyal0bl[66] lyal0bl[65] lyal0bl[64] lyal0bl[63] lyal0bl[62] lyal0bl[61]
+ lyal0bl[60] lyal0bl[59] lyal0bl[58] lyal0bl[57] lyal0bl[56] lyal0bl[55] lyal0bl[54]
+ lyal0bl[53] lyal0bl[52] lyal0bl[51] lyal0bl[50] lyal0bl[49] lyal0bl[48] lyal0bl[47]
+ lyal0bl[46] lyal0bl[45] lyal0bl[44] lyal0bl[43] lyal0bl[42] lyal0bl[41] lyal0bl[40]
+ lyal0bl[39] lyal0bl[38] lyal0bl[37] lyal0bl[36] lyal0bl[35] lyal0bl[34] lyal0bl[33]
+ lyal0bl[32] lyal0bl[31] lyal0bl[30] lyal0bl[29] lyal0bl[28] lyal0bl[27] lyal0bl[26]
+ lyal0bl[25] lyal0bl[24] lyal0bl[23] lyal0bl[22] lyal0bl[21] lyal0bl[20] lyal0bl[19]
+ lyal0bl[18] lyal0bl[17] lyal0bl[16] lyal0bl[15] lyal0bl[14] lyal0bl[13] lyal0bl[12]
+ lyal0bl[11] lyal0bl[10] lyal0bl[9] lyal0bl[8] lyal0bl[7] lyal0bl[6] lyal0bl[5]
+ lyal0bl[4] lyal0bl[3] lyal0bl[2] lyal0bl[1] lyal0bl[0] lyal0blnn[66] lyal0blnn[65]
+ lyal0blnn[64] lyal0blnn[63] lyal0blnn[62] lyal0blnn[61] lyal0blnn[60] lyal0blnn[59]
+ lyal0blnn[58] lyal0blnn[57] lyal0blnn[56] lyal0blnn[55] lyal0blnn[54] lyal0blnn[53]
+ lyal0blnn[52] lyal0blnn[51] lyal0blnn[50] lyal0blnn[49] lyal0blnn[48] lyal0blnn[47]
+ lyal0blnn[46] lyal0blnn[45] lyal0blnn[44] lyal0blnn[43] lyal0blnn[42] lyal0blnn[41]
+ lyal0blnn[40] lyal0blnn[39] lyal0blnn[38] lyal0blnn[37] lyal0blnn[36] lyal0blnn[35]
+ lyal0blnn[34] lyal0blnn[33] lyal0blnn[32] lyal0blnn[31] lyal0blnn[30] lyal0blnn[29]
+ lyal0blnn[28] lyal0blnn[27] lyal0blnn[26] lyal0blnn[25] lyal0blnn[24] lyal0blnn[23]
+ lyal0blnn[22] lyal0blnn[21] lyal0blnn[20] lyal0blnn[19] lyal0blnn[18] lyal0blnn[17]
+ lyal0blnn[16] lyal0blnn[15] lyal0blnn[14] lyal0blnn[13] lyal0blnn[12] lyal0blnn[11]
+ lyal0blnn[10] lyal0blnn[9] lyal0blnn[8] lyal0blnn[7] lyal0blnn[6] lyal0blnn[5]
+ lyal0blnn[4] lyal0blnn[3] lyal0blnn[2] lyal0blnn[1] lyal0blnn[0] nbl_kicknn pcnn0
+ pcnn1 rddataout[66] rddataout[65] rddataout[64] rddataout[63] rddataout[62] rddataout[61]
+ rddataout[60] rddataout[59] rddataout[58] rddataout[57] rddataout[56] rddataout[55]
+ rddataout[54] rddataout[53] rddataout[52] rddataout[51] rddataout[50] rddataout[49]
+ rddataout[48] rddataout[47] rddataout[46] rddataout[45] rddataout[44] rddataout[43]
+ rddataout[42] rddataout[41] rddataout[40] rddataout[39] rddataout[38] rddataout[37]
+ rddataout[36] rddataout[35] rddataout[34] rddataout[33] rddataout[32] rddataout[31]
+ rddataout[30] rddataout[29] rddataout[28] rddataout[27] rddataout[26] rddataout[25]
+ rddataout[24] rddataout[23] rddataout[22] rddataout[21] rddataout[20] rddataout[19]
+ rddataout[18] rddataout[17] rddataout[16] rddataout[15] rddataout[14] rddataout[13]
+ rddataout[12] rddataout[11] rddataout[10] rddataout[9] rddataout[8] rddataout[7]
+ rddataout[6] rddataout[5] rddataout[4] rddataout[3] rddataout[2] rddataout[1]
+ rddataout[0] rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2]
+ rdysel1[1] rdysel1[0] redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc
+ vss waenn[2] waenn[1] waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250]
+ wl0[249] wl0[248] wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241]
+ wl0[240] wl0[239] wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232]
+ wl0[231] wl0[230] wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223]
+ wl0[222] wl0[221] wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214]
+ wl0[213] wl0[212] wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205]
+ wl0[204] wl0[203] wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196]
+ wl0[195] wl0[194] wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187]
+ wl0[186] wl0[185] wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178]
+ wl0[177] wl0[176] wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169]
+ wl0[168] wl0[167] wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160]
+ wl0[159] wl0[158] wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151]
+ wl0[150] wl0[149] wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142]
+ wl0[141] wl0[140] wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133]
+ wl0[132] wl0[131] wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124]
+ wl0[123] wl0[122] wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115]
+ wl0[114] wl0[113] wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106]
+ wl0[105] wl0[104] wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97]
+ wl0[96] wl0[95] wl0[94] wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87]
+ wl0[86] wl0[85] wl0[84] wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77]
+ wl0[76] wl0[75] wl0[74] wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67]
+ wl0[66] wl0[65] wl0[64] wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57]
+ wl0[56] wl0[55] wl0[54] wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47]
+ wl0[46] wl0[45] wl0[44] wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37]
+ wl0[36] wl0[35] wl0[34] wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27]
+ wl0[26] wl0[25] wl0[24] wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17]
+ wl0[16] wl0[15] wl0[14] wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6]
+ wl0[5] wl0[4] wl0[3] wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252]
+ wl1[251] wl1[250] wl1[249] wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243]
+ wl1[242] wl1[241] wl1[240] wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234]
+ wl1[233] wl1[232] wl1[231] wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225]
+ wl1[224] wl1[223] wl1[222] wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216]
+ wl1[215] wl1[214] wl1[213] wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207]
+ wl1[206] wl1[205] wl1[204] wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198]
+ wl1[197] wl1[196] wl1[195] wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189]
+ wl1[188] wl1[187] wl1[186] wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180]
+ wl1[179] wl1[178] wl1[177] wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171]
+ wl1[170] wl1[169] wl1[168] wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162]
+ wl1[161] wl1[160] wl1[159] wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153]
+ wl1[152] wl1[151] wl1[150] wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144]
+ wl1[143] wl1[142] wl1[141] wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135]
+ wl1[134] wl1[133] wl1[132] wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126]
+ wl1[125] wl1[124] wl1[123] wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117]
+ wl1[116] wl1[115] wl1[114] wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108]
+ wl1[107] wl1[106] wl1[105] wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99]
+ wl1[98] wl1[97] wl1[96] wl1[95] wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89]
+ wl1[88] wl1[87] wl1[86] wl1[85] wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79]
+ wl1[78] wl1[77] wl1[76] wl1[75] wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69]
+ wl1[68] wl1[67] wl1[66] wl1[65] wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59]
+ wl1[58] wl1[57] wl1[56] wl1[55] wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49]
+ wl1[48] wl1[47] wl1[46] wl1[45] wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39]
+ wl1[38] wl1[37] wl1[36] wl1[35] wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29]
+ wl1[28] wl1[27] wl1[26] wl1[25] wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19]
+ wl1[18] wl1[17] wl1[16] wl1[15] wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9]
+ wl1[8] wl1[7] wl1[6] wl1[5] wl1[4] wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3]
+ wrcolsel0[2] wrcolsel0[1] wrcolsel0[0] wrcolsel1[3] wrcolsel1[2] wrcolsel1[1]
+ wrcolsel1[0] wrdataen
*.PININFO idin1l[66]:I idin1l[65]:I idin1l[64]:I idin1l[63]:I idin1l[62]:I idin1l[61]:I idin1l[60]:I idin1l[59]:I idin1l[58]:I idin1l[57]:I idin1l[56]:I idin1l[55]:I idin1l[54]:I idin1l[53]:I idin1l[52]:I idin1l[51]:I idin1l[50]:I idin1l[49]:I idin1l[48]:I idin1l[47]:I
*.PININFO idin1l[46]:I idin1l[45]:I idin1l[44]:I idin1l[43]:I idin1l[42]:I idin1l[41]:I idin1l[40]:I idin1l[39]:I idin1l[38]:I idin1l[37]:I idin1l[36]:I idin1l[35]:I idin1l[34]:I idin1l[33]:I idin1l[32]:I idin1l[31]:I idin1l[30]:I idin1l[29]:I idin1l[28]:I idin1l[27]:I
*.PININFO idin1l[26]:I idin1l[25]:I idin1l[24]:I idin1l[23]:I idin1l[22]:I idin1l[21]:I idin1l[20]:I idin1l[19]:I idin1l[18]:I idin1l[17]:I idin1l[16]:I idin1l[15]:I idin1l[14]:I idin1l[13]:I idin1l[12]:I idin1l[11]:I idin1l[10]:I idin1l[9]:I idin1l[8]:I idin1l[7]:I
*.PININFO idin1l[6]:I idin1l[5]:I idin1l[4]:I idin1l[3]:I idin1l[2]:I idin1l[1]:I idin1l[0]:I lyaennn:I lyal0bl[66]:I lyal0bl[65]:I lyal0bl[64]:I lyal0bl[63]:I lyal0bl[62]:I lyal0bl[61]:I lyal0bl[60]:I lyal0bl[59]:I lyal0bl[58]:I lyal0bl[57]:I lyal0bl[56]:I lyal0bl[55]:I
*.PININFO lyal0bl[54]:I lyal0bl[53]:I lyal0bl[52]:I lyal0bl[51]:I lyal0bl[50]:I lyal0bl[49]:I lyal0bl[48]:I lyal0bl[47]:I lyal0bl[46]:I lyal0bl[45]:I lyal0bl[44]:I lyal0bl[43]:I lyal0bl[42]:I lyal0bl[41]:I lyal0bl[40]:I lyal0bl[39]:I lyal0bl[38]:I lyal0bl[37]:I lyal0bl[36]:I lyal0bl[35]:I
*.PININFO lyal0bl[34]:I lyal0bl[33]:I lyal0bl[32]:I lyal0bl[31]:I lyal0bl[30]:I lyal0bl[29]:I lyal0bl[28]:I lyal0bl[27]:I lyal0bl[26]:I lyal0bl[25]:I lyal0bl[24]:I lyal0bl[23]:I lyal0bl[22]:I lyal0bl[21]:I lyal0bl[20]:I lyal0bl[19]:I lyal0bl[18]:I lyal0bl[17]:I lyal0bl[16]:I lyal0bl[15]:I
*.PININFO lyal0bl[14]:I lyal0bl[13]:I lyal0bl[12]:I lyal0bl[11]:I lyal0bl[10]:I lyal0bl[9]:I lyal0bl[8]:I lyal0bl[7]:I lyal0bl[6]:I lyal0bl[5]:I lyal0bl[4]:I lyal0bl[3]:I lyal0bl[2]:I lyal0bl[1]:I lyal0bl[0]:I lyal0blnn[66]:I lyal0blnn[65]:I lyal0blnn[64]:I lyal0blnn[63]:I lyal0blnn[62]:I
*.PININFO lyal0blnn[61]:I lyal0blnn[60]:I lyal0blnn[59]:I lyal0blnn[58]:I lyal0blnn[57]:I lyal0blnn[56]:I lyal0blnn[55]:I lyal0blnn[54]:I lyal0blnn[53]:I lyal0blnn[52]:I lyal0blnn[51]:I lyal0blnn[50]:I lyal0blnn[49]:I lyal0blnn[48]:I lyal0blnn[47]:I lyal0blnn[46]:I lyal0blnn[45]:I lyal0blnn[44]:I lyal0blnn[43]:I lyal0blnn[42]:I
*.PININFO lyal0blnn[41]:I lyal0blnn[40]:I lyal0blnn[39]:I lyal0blnn[38]:I lyal0blnn[37]:I lyal0blnn[36]:I lyal0blnn[35]:I lyal0blnn[34]:I lyal0blnn[33]:I lyal0blnn[32]:I lyal0blnn[31]:I lyal0blnn[30]:I lyal0blnn[29]:I lyal0blnn[28]:I lyal0blnn[27]:I lyal0blnn[26]:I lyal0blnn[25]:I lyal0blnn[24]:I lyal0blnn[23]:I lyal0blnn[22]:I
*.PININFO lyal0blnn[21]:I lyal0blnn[20]:I lyal0blnn[19]:I lyal0blnn[18]:I lyal0blnn[17]:I lyal0blnn[16]:I lyal0blnn[15]:I lyal0blnn[14]:I lyal0blnn[13]:I lyal0blnn[12]:I lyal0blnn[11]:I lyal0blnn[10]:I lyal0blnn[9]:I lyal0blnn[8]:I lyal0blnn[7]:I lyal0blnn[6]:I lyal0blnn[5]:I lyal0blnn[4]:I lyal0blnn[3]:I lyal0blnn[2]:I
*.PININFO lyal0blnn[1]:I lyal0blnn[0]:I nbl_kicknn:I pcnn0:I pcnn1:I rddataout[66]:O rddataout[65]:O rddataout[64]:O rddataout[63]:O rddataout[62]:O rddataout[61]:O rddataout[60]:O rddataout[59]:O rddataout[58]:O rddataout[57]:O rddataout[56]:O rddataout[55]:O rddataout[54]:O rddataout[53]:O rddataout[52]:O
*.PININFO rddataout[51]:O rddataout[50]:O rddataout[49]:O rddataout[48]:O rddataout[47]:O rddataout[46]:O rddataout[45]:O rddataout[44]:O rddataout[43]:O rddataout[42]:O rddataout[41]:O rddataout[40]:O rddataout[39]:O rddataout[38]:O rddataout[37]:O rddataout[36]:O rddataout[35]:O rddataout[34]:O rddataout[33]:O rddataout[32]:O
*.PININFO rddataout[31]:O rddataout[30]:O rddataout[29]:O rddataout[28]:O rddataout[27]:O rddataout[26]:O rddataout[25]:O rddataout[24]:O rddataout[23]:O rddataout[22]:O rddataout[21]:O rddataout[20]:O rddataout[19]:O rddataout[18]:O rddataout[17]:O rddataout[16]:O rddataout[15]:O rddataout[14]:O rddataout[13]:O rddataout[12]:O
*.PININFO rddataout[11]:O rddataout[10]:O rddataout[9]:O rddataout[8]:O rddataout[7]:O rddataout[6]:O rddataout[5]:O rddataout[4]:O rddataout[3]:O rddataout[2]:O rddataout[1]:O rddataout[0]:O rdysel0[3]:I rdysel0[2]:I rdysel0[1]:I rdysel0[0]:I rdysel1[3]:I rdysel1[2]:I rdysel1[1]:I rdysel1[0]:I
*.PININFO redwl0[1]:I redwl0[0]:I redwl1[1]:I redwl1[0]:I saenn:I sapchnn:I vcc:I vss:I waenn[2]:I waenn[1]:I waenn[0]:I wl0[255]:I wl0[254]:I wl0[253]:I wl0[252]:I wl0[251]:I wl0[250]:I wl0[249]:I wl0[248]:I wl0[247]:I
*.PININFO wl0[246]:I wl0[245]:I wl0[244]:I wl0[243]:I wl0[242]:I wl0[241]:I wl0[240]:I wl0[239]:I wl0[238]:I wl0[237]:I wl0[236]:I wl0[235]:I wl0[234]:I wl0[233]:I wl0[232]:I wl0[231]:I wl0[230]:I wl0[229]:I wl0[228]:I wl0[227]:I
*.PININFO wl0[226]:I wl0[225]:I wl0[224]:I wl0[223]:I wl0[222]:I wl0[221]:I wl0[220]:I wl0[219]:I wl0[218]:I wl0[217]:I wl0[216]:I wl0[215]:I wl0[214]:I wl0[213]:I wl0[212]:I wl0[211]:I wl0[210]:I wl0[209]:I wl0[208]:I wl0[207]:I
*.PININFO wl0[206]:I wl0[205]:I wl0[204]:I wl0[203]:I wl0[202]:I wl0[201]:I wl0[200]:I wl0[199]:I wl0[198]:I wl0[197]:I wl0[196]:I wl0[195]:I wl0[194]:I wl0[193]:I wl0[192]:I wl0[191]:I wl0[190]:I wl0[189]:I wl0[188]:I wl0[187]:I
*.PININFO wl0[186]:I wl0[185]:I wl0[184]:I wl0[183]:I wl0[182]:I wl0[181]:I wl0[180]:I wl0[179]:I wl0[178]:I wl0[177]:I wl0[176]:I wl0[175]:I wl0[174]:I wl0[173]:I wl0[172]:I wl0[171]:I wl0[170]:I wl0[169]:I wl0[168]:I wl0[167]:I
*.PININFO wl0[166]:I wl0[165]:I wl0[164]:I wl0[163]:I wl0[162]:I wl0[161]:I wl0[160]:I wl0[159]:I wl0[158]:I wl0[157]:I wl0[156]:I wl0[155]:I wl0[154]:I wl0[153]:I wl0[152]:I wl0[151]:I wl0[150]:I wl0[149]:I wl0[148]:I wl0[147]:I
*.PININFO wl0[146]:I wl0[145]:I wl0[144]:I wl0[143]:I wl0[142]:I wl0[141]:I wl0[140]:I wl0[139]:I wl0[138]:I wl0[137]:I wl0[136]:I wl0[135]:I wl0[134]:I wl0[133]:I wl0[132]:I wl0[131]:I wl0[130]:I wl0[129]:I wl0[128]:I wl0[127]:I
*.PININFO wl0[126]:I wl0[125]:I wl0[124]:I wl0[123]:I wl0[122]:I wl0[121]:I wl0[120]:I wl0[119]:I wl0[118]:I wl0[117]:I wl0[116]:I wl0[115]:I wl0[114]:I wl0[113]:I wl0[112]:I wl0[111]:I wl0[110]:I wl0[109]:I wl0[108]:I wl0[107]:I
*.PININFO wl0[106]:I wl0[105]:I wl0[104]:I wl0[103]:I wl0[102]:I wl0[101]:I wl0[100]:I wl0[99]:I wl0[98]:I wl0[97]:I wl0[96]:I wl0[95]:I wl0[94]:I wl0[93]:I wl0[92]:I wl0[91]:I wl0[90]:I wl0[89]:I wl0[88]:I wl0[87]:I
*.PININFO wl0[86]:I wl0[85]:I wl0[84]:I wl0[83]:I wl0[82]:I wl0[81]:I wl0[80]:I wl0[79]:I wl0[78]:I wl0[77]:I wl0[76]:I wl0[75]:I wl0[74]:I wl0[73]:I wl0[72]:I wl0[71]:I wl0[70]:I wl0[69]:I wl0[68]:I wl0[67]:I
*.PININFO wl0[66]:I wl0[65]:I wl0[64]:I wl0[63]:I wl0[62]:I wl0[61]:I wl0[60]:I wl0[59]:I wl0[58]:I wl0[57]:I wl0[56]:I wl0[55]:I wl0[54]:I wl0[53]:I wl0[52]:I wl0[51]:I wl0[50]:I wl0[49]:I wl0[48]:I wl0[47]:I
*.PININFO wl0[46]:I wl0[45]:I wl0[44]:I wl0[43]:I wl0[42]:I wl0[41]:I wl0[40]:I wl0[39]:I wl0[38]:I wl0[37]:I wl0[36]:I wl0[35]:I wl0[34]:I wl0[33]:I wl0[32]:I wl0[31]:I wl0[30]:I wl0[29]:I wl0[28]:I wl0[27]:I
*.PININFO wl0[26]:I wl0[25]:I wl0[24]:I wl0[23]:I wl0[22]:I wl0[21]:I wl0[20]:I wl0[19]:I wl0[18]:I wl0[17]:I wl0[16]:I wl0[15]:I wl0[14]:I wl0[13]:I wl0[12]:I wl0[11]:I wl0[10]:I wl0[9]:I wl0[8]:I wl0[7]:I
*.PININFO wl0[6]:I wl0[5]:I wl0[4]:I wl0[3]:I wl0[2]:I wl0[1]:I wl0[0]:I wl1[255]:I wl1[254]:I wl1[253]:I wl1[252]:I wl1[251]:I wl1[250]:I wl1[249]:I wl1[248]:I wl1[247]:I wl1[246]:I wl1[245]:I wl1[244]:I wl1[243]:I
*.PININFO wl1[242]:I wl1[241]:I wl1[240]:I wl1[239]:I wl1[238]:I wl1[237]:I wl1[236]:I wl1[235]:I wl1[234]:I wl1[233]:I wl1[232]:I wl1[231]:I wl1[230]:I wl1[229]:I wl1[228]:I wl1[227]:I wl1[226]:I wl1[225]:I wl1[224]:I wl1[223]:I
*.PININFO wl1[222]:I wl1[221]:I wl1[220]:I wl1[219]:I wl1[218]:I wl1[217]:I wl1[216]:I wl1[215]:I wl1[214]:I wl1[213]:I wl1[212]:I wl1[211]:I wl1[210]:I wl1[209]:I wl1[208]:I wl1[207]:I wl1[206]:I wl1[205]:I wl1[204]:I wl1[203]:I
*.PININFO wl1[202]:I wl1[201]:I wl1[200]:I wl1[199]:I wl1[198]:I wl1[197]:I wl1[196]:I wl1[195]:I wl1[194]:I wl1[193]:I wl1[192]:I wl1[191]:I wl1[190]:I wl1[189]:I wl1[188]:I wl1[187]:I wl1[186]:I wl1[185]:I wl1[184]:I wl1[183]:I
*.PININFO wl1[182]:I wl1[181]:I wl1[180]:I wl1[179]:I wl1[178]:I wl1[177]:I wl1[176]:I wl1[175]:I wl1[174]:I wl1[173]:I wl1[172]:I wl1[171]:I wl1[170]:I wl1[169]:I wl1[168]:I wl1[167]:I wl1[166]:I wl1[165]:I wl1[164]:I wl1[163]:I
*.PININFO wl1[162]:I wl1[161]:I wl1[160]:I wl1[159]:I wl1[158]:I wl1[157]:I wl1[156]:I wl1[155]:I wl1[154]:I wl1[153]:I wl1[152]:I wl1[151]:I wl1[150]:I wl1[149]:I wl1[148]:I wl1[147]:I wl1[146]:I wl1[145]:I wl1[144]:I wl1[143]:I
*.PININFO wl1[142]:I wl1[141]:I wl1[140]:I wl1[139]:I wl1[138]:I wl1[137]:I wl1[136]:I wl1[135]:I wl1[134]:I wl1[133]:I wl1[132]:I wl1[131]:I wl1[130]:I wl1[129]:I wl1[128]:I wl1[127]:I wl1[126]:I wl1[125]:I wl1[124]:I wl1[123]:I
*.PININFO wl1[122]:I wl1[121]:I wl1[120]:I wl1[119]:I wl1[118]:I wl1[117]:I wl1[116]:I wl1[115]:I wl1[114]:I wl1[113]:I wl1[112]:I wl1[111]:I wl1[110]:I wl1[109]:I wl1[108]:I wl1[107]:I wl1[106]:I wl1[105]:I wl1[104]:I wl1[103]:I
*.PININFO wl1[102]:I wl1[101]:I wl1[100]:I wl1[99]:I wl1[98]:I wl1[97]:I wl1[96]:I wl1[95]:I wl1[94]:I wl1[93]:I wl1[92]:I wl1[91]:I wl1[90]:I wl1[89]:I wl1[88]:I wl1[87]:I wl1[86]:I wl1[85]:I wl1[84]:I wl1[83]:I
*.PININFO wl1[82]:I wl1[81]:I wl1[80]:I wl1[79]:I wl1[78]:I wl1[77]:I wl1[76]:I wl1[75]:I wl1[74]:I wl1[73]:I wl1[72]:I wl1[71]:I wl1[70]:I wl1[69]:I wl1[68]:I wl1[67]:I wl1[66]:I wl1[65]:I wl1[64]:I wl1[63]:I
*.PININFO wl1[62]:I wl1[61]:I wl1[60]:I wl1[59]:I wl1[58]:I wl1[57]:I wl1[56]:I wl1[55]:I wl1[54]:I wl1[53]:I wl1[52]:I wl1[51]:I wl1[50]:I wl1[49]:I wl1[48]:I wl1[47]:I wl1[46]:I wl1[45]:I wl1[44]:I wl1[43]:I
*.PININFO wl1[42]:I wl1[41]:I wl1[40]:I wl1[39]:I wl1[38]:I wl1[37]:I wl1[36]:I wl1[35]:I wl1[34]:I wl1[33]:I wl1[32]:I wl1[31]:I wl1[30]:I wl1[29]:I wl1[28]:I wl1[27]:I wl1[26]:I wl1[25]:I wl1[24]:I wl1[23]:I
*.PININFO wl1[22]:I wl1[21]:I wl1[20]:I wl1[19]:I wl1[18]:I wl1[17]:I wl1[16]:I wl1[15]:I wl1[14]:I wl1[13]:I wl1[12]:I wl1[11]:I wl1[10]:I wl1[9]:I wl1[8]:I wl1[7]:I wl1[6]:I wl1[5]:I wl1[4]:I wl1[3]:I
*.PININFO wl1[2]:I wl1[1]:I wl1[0]:I wrclk:I wrcolsel0[3]:I wrcolsel0[2]:I wrcolsel0[1]:I wrcolsel0[0]:I wrcolsel1[3]:I wrcolsel1[2]:I wrcolsel1[1]:I wrcolsel1[0]:I wrdataen:I
Xslice[66] idin1l[66] lyaennn lyal0bl[66] lyal0blnn[66] nbl_kicknn pcnn0 pcnn1 rddataout[66]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[65] idin1l[65] lyaennn lyal0bl[65] lyal0blnn[65] nbl_kicknn pcnn0 pcnn1 rddataout[65]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[64] idin1l[64] lyaennn lyal0bl[64] lyal0blnn[64] nbl_kicknn pcnn0 pcnn1 rddataout[64]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[63] idin1l[63] lyaennn lyal0bl[63] lyal0blnn[63] nbl_kicknn pcnn0 pcnn1 rddataout[63]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[62] idin1l[62] lyaennn lyal0bl[62] lyal0blnn[62] nbl_kicknn pcnn0 pcnn1 rddataout[62]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[61] idin1l[61] lyaennn lyal0bl[61] lyal0blnn[61] nbl_kicknn pcnn0 pcnn1 rddataout[61]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[60] idin1l[60] lyaennn lyal0bl[60] lyal0blnn[60] nbl_kicknn pcnn0 pcnn1 rddataout[60]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[59] idin1l[59] lyaennn lyal0bl[59] lyal0blnn[59] nbl_kicknn pcnn0 pcnn1 rddataout[59]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[58] idin1l[58] lyaennn lyal0bl[58] lyal0blnn[58] nbl_kicknn pcnn0 pcnn1 rddataout[58]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[57] idin1l[57] lyaennn lyal0bl[57] lyal0blnn[57] nbl_kicknn pcnn0 pcnn1 rddataout[57]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[56] idin1l[56] lyaennn lyal0bl[56] lyal0blnn[56] nbl_kicknn pcnn0 pcnn1 rddataout[56]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[55] idin1l[55] lyaennn lyal0bl[55] lyal0blnn[55] nbl_kicknn pcnn0 pcnn1 rddataout[55]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[54] idin1l[54] lyaennn lyal0bl[54] lyal0blnn[54] nbl_kicknn pcnn0 pcnn1 rddataout[54]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[53] idin1l[53] lyaennn lyal0bl[53] lyal0blnn[53] nbl_kicknn pcnn0 pcnn1 rddataout[53]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[52] idin1l[52] lyaennn lyal0bl[52] lyal0blnn[52] nbl_kicknn pcnn0 pcnn1 rddataout[52]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[51] idin1l[51] lyaennn lyal0bl[51] lyal0blnn[51] nbl_kicknn pcnn0 pcnn1 rddataout[51]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[50] idin1l[50] lyaennn lyal0bl[50] lyal0blnn[50] nbl_kicknn pcnn0 pcnn1 rddataout[50]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[49] idin1l[49] lyaennn lyal0bl[49] lyal0blnn[49] nbl_kicknn pcnn0 pcnn1 rddataout[49]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[48] idin1l[48] lyaennn lyal0bl[48] lyal0blnn[48] nbl_kicknn pcnn0 pcnn1 rddataout[48]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[47] idin1l[47] lyaennn lyal0bl[47] lyal0blnn[47] nbl_kicknn pcnn0 pcnn1 rddataout[47]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[46] idin1l[46] lyaennn lyal0bl[46] lyal0blnn[46] nbl_kicknn pcnn0 pcnn1 rddataout[46]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[45] idin1l[45] lyaennn lyal0bl[45] lyal0blnn[45] nbl_kicknn pcnn0 pcnn1 rddataout[45]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[44] idin1l[44] lyaennn lyal0bl[44] lyal0blnn[44] nbl_kicknn pcnn0 pcnn1 rddataout[44]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[43] idin1l[43] lyaennn lyal0bl[43] lyal0blnn[43] nbl_kicknn pcnn0 pcnn1 rddataout[43]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[42] idin1l[42] lyaennn lyal0bl[42] lyal0blnn[42] nbl_kicknn pcnn0 pcnn1 rddataout[42]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[41] idin1l[41] lyaennn lyal0bl[41] lyal0blnn[41] nbl_kicknn pcnn0 pcnn1 rddataout[41]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[40] idin1l[40] lyaennn lyal0bl[40] lyal0blnn[40] nbl_kicknn pcnn0 pcnn1 rddataout[40]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[39] idin1l[39] lyaennn lyal0bl[39] lyal0blnn[39] nbl_kicknn pcnn0 pcnn1 rddataout[39]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[38] idin1l[38] lyaennn lyal0bl[38] lyal0blnn[38] nbl_kicknn pcnn0 pcnn1 rddataout[38]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[37] idin1l[37] lyaennn lyal0bl[37] lyal0blnn[37] nbl_kicknn pcnn0 pcnn1 rddataout[37]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[36] idin1l[36] lyaennn lyal0bl[36] lyal0blnn[36] nbl_kicknn pcnn0 pcnn1 rddataout[36]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[35] idin1l[35] lyaennn lyal0bl[35] lyal0blnn[35] nbl_kicknn pcnn0 pcnn1 rddataout[35]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[34] idin1l[34] lyaennn lyal0bl[34] lyal0blnn[34] nbl_kicknn pcnn0 pcnn1 rddataout[34]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[33] idin1l[33] lyaennn lyal0bl[33] lyal0blnn[33] nbl_kicknn pcnn0 pcnn1 rddataout[33]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[32] idin1l[32] lyaennn lyal0bl[32] lyal0blnn[32] nbl_kicknn pcnn0 pcnn1 rddataout[32]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[31] idin1l[31] lyaennn lyal0bl[31] lyal0blnn[31] nbl_kicknn pcnn0 pcnn1 rddataout[31]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[30] idin1l[30] lyaennn lyal0bl[30] lyal0blnn[30] nbl_kicknn pcnn0 pcnn1 rddataout[30]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[29] idin1l[29] lyaennn lyal0bl[29] lyal0blnn[29] nbl_kicknn pcnn0 pcnn1 rddataout[29]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[28] idin1l[28] lyaennn lyal0bl[28] lyal0blnn[28] nbl_kicknn pcnn0 pcnn1 rddataout[28]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[27] idin1l[27] lyaennn lyal0bl[27] lyal0blnn[27] nbl_kicknn pcnn0 pcnn1 rddataout[27]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[26] idin1l[26] lyaennn lyal0bl[26] lyal0blnn[26] nbl_kicknn pcnn0 pcnn1 rddataout[26]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[25] idin1l[25] lyaennn lyal0bl[25] lyal0blnn[25] nbl_kicknn pcnn0 pcnn1 rddataout[25]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[24] idin1l[24] lyaennn lyal0bl[24] lyal0blnn[24] nbl_kicknn pcnn0 pcnn1 rddataout[24]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[23] idin1l[23] lyaennn lyal0bl[23] lyal0blnn[23] nbl_kicknn pcnn0 pcnn1 rddataout[23]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[22] idin1l[22] lyaennn lyal0bl[22] lyal0blnn[22] nbl_kicknn pcnn0 pcnn1 rddataout[22]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[21] idin1l[21] lyaennn lyal0bl[21] lyal0blnn[21] nbl_kicknn pcnn0 pcnn1 rddataout[21]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[20] idin1l[20] lyaennn lyal0bl[20] lyal0blnn[20] nbl_kicknn pcnn0 pcnn1 rddataout[20]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[19] idin1l[19] lyaennn lyal0bl[19] lyal0blnn[19] nbl_kicknn pcnn0 pcnn1 rddataout[19]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[18] idin1l[18] lyaennn lyal0bl[18] lyal0blnn[18] nbl_kicknn pcnn0 pcnn1 rddataout[18]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[17] idin1l[17] lyaennn lyal0bl[17] lyal0blnn[17] nbl_kicknn pcnn0 pcnn1 rddataout[17]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[16] idin1l[16] lyaennn lyal0bl[16] lyal0blnn[16] nbl_kicknn pcnn0 pcnn1 rddataout[16]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[15] idin1l[15] lyaennn lyal0bl[15] lyal0blnn[15] nbl_kicknn pcnn0 pcnn1 rddataout[15]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[14] idin1l[14] lyaennn lyal0bl[14] lyal0blnn[14] nbl_kicknn pcnn0 pcnn1 rddataout[14]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[13] idin1l[13] lyaennn lyal0bl[13] lyal0blnn[13] nbl_kicknn pcnn0 pcnn1 rddataout[13]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[12] idin1l[12] lyaennn lyal0bl[12] lyal0blnn[12] nbl_kicknn pcnn0 pcnn1 rddataout[12]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[11] idin1l[11] lyaennn lyal0bl[11] lyal0blnn[11] nbl_kicknn pcnn0 pcnn1 rddataout[11]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[10] idin1l[10] lyaennn lyal0bl[10] lyal0blnn[10] nbl_kicknn pcnn0 pcnn1 rddataout[10]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[9] idin1l[9] lyaennn lyal0bl[9] lyal0blnn[9] nbl_kicknn pcnn0 pcnn1 rddataout[9]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[8] idin1l[8] lyaennn lyal0bl[8] lyal0blnn[8] nbl_kicknn pcnn0 pcnn1 rddataout[8]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[7] idin1l[7] lyaennn lyal0bl[7] lyal0blnn[7] nbl_kicknn pcnn0 pcnn1 rddataout[7]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[6] idin1l[6] lyaennn lyal0bl[6] lyal0blnn[6] nbl_kicknn pcnn0 pcnn1 rddataout[6]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[5] idin1l[5] lyaennn lyal0bl[5] lyal0blnn[5] nbl_kicknn pcnn0 pcnn1 rddataout[5]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[4] idin1l[4] lyaennn lyal0bl[4] lyal0blnn[4] nbl_kicknn pcnn0 pcnn1 rddataout[4]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[3] idin1l[3] lyaennn lyal0bl[3] lyal0blnn[3] nbl_kicknn pcnn0 pcnn1 rddataout[3]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[2] idin1l[2] lyaennn lyal0bl[2] lyal0blnn[2] nbl_kicknn pcnn0 pcnn1 rddataout[2]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[1] idin1l[1] lyaennn lyal0bl[1] lyal0blnn[1] nbl_kicknn pcnn0 pcnn1 rddataout[1]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
Xslice[0] idin1l[0] lyaennn lyal0bl[0] lyal0blnn[0] nbl_kicknn pcnn0 pcnn1 rddataout[0]
+ rdysel0[3] rdysel0[2] rdysel0[1] rdysel0[0] rdysel1[3] rdysel1[2] rdysel1[1] rdysel1[0]
+ redwl0[1] redwl0[0] redwl1[1] redwl1[0] saenn sapchnn vcc vss waenn[2] waenn[1]
+ waenn[0] wl0[255] wl0[254] wl0[253] wl0[252] wl0[251] wl0[250] wl0[249] wl0[248]
+ wl0[247] wl0[246] wl0[245] wl0[244] wl0[243] wl0[242] wl0[241] wl0[240] wl0[239]
+ wl0[238] wl0[237] wl0[236] wl0[235] wl0[234] wl0[233] wl0[232] wl0[231] wl0[230]
+ wl0[229] wl0[228] wl0[227] wl0[226] wl0[225] wl0[224] wl0[223] wl0[222] wl0[221]
+ wl0[220] wl0[219] wl0[218] wl0[217] wl0[216] wl0[215] wl0[214] wl0[213] wl0[212]
+ wl0[211] wl0[210] wl0[209] wl0[208] wl0[207] wl0[206] wl0[205] wl0[204] wl0[203]
+ wl0[202] wl0[201] wl0[200] wl0[199] wl0[198] wl0[197] wl0[196] wl0[195] wl0[194]
+ wl0[193] wl0[192] wl0[191] wl0[190] wl0[189] wl0[188] wl0[187] wl0[186] wl0[185]
+ wl0[184] wl0[183] wl0[182] wl0[181] wl0[180] wl0[179] wl0[178] wl0[177] wl0[176]
+ wl0[175] wl0[174] wl0[173] wl0[172] wl0[171] wl0[170] wl0[169] wl0[168] wl0[167]
+ wl0[166] wl0[165] wl0[164] wl0[163] wl0[162] wl0[161] wl0[160] wl0[159] wl0[158]
+ wl0[157] wl0[156] wl0[155] wl0[154] wl0[153] wl0[152] wl0[151] wl0[150] wl0[149]
+ wl0[148] wl0[147] wl0[146] wl0[145] wl0[144] wl0[143] wl0[142] wl0[141] wl0[140]
+ wl0[139] wl0[138] wl0[137] wl0[136] wl0[135] wl0[134] wl0[133] wl0[132] wl0[131]
+ wl0[130] wl0[129] wl0[128] wl0[127] wl0[126] wl0[125] wl0[124] wl0[123] wl0[122]
+ wl0[121] wl0[120] wl0[119] wl0[118] wl0[117] wl0[116] wl0[115] wl0[114] wl0[113]
+ wl0[112] wl0[111] wl0[110] wl0[109] wl0[108] wl0[107] wl0[106] wl0[105] wl0[104]
+ wl0[103] wl0[102] wl0[101] wl0[100] wl0[99] wl0[98] wl0[97] wl0[96] wl0[95] wl0[94]
+ wl0[93] wl0[92] wl0[91] wl0[90] wl0[89] wl0[88] wl0[87] wl0[86] wl0[85] wl0[84]
+ wl0[83] wl0[82] wl0[81] wl0[80] wl0[79] wl0[78] wl0[77] wl0[76] wl0[75] wl0[74]
+ wl0[73] wl0[72] wl0[71] wl0[70] wl0[69] wl0[68] wl0[67] wl0[66] wl0[65] wl0[64]
+ wl0[63] wl0[62] wl0[61] wl0[60] wl0[59] wl0[58] wl0[57] wl0[56] wl0[55] wl0[54]
+ wl0[53] wl0[52] wl0[51] wl0[50] wl0[49] wl0[48] wl0[47] wl0[46] wl0[45] wl0[44]
+ wl0[43] wl0[42] wl0[41] wl0[40] wl0[39] wl0[38] wl0[37] wl0[36] wl0[35] wl0[34]
+ wl0[33] wl0[32] wl0[31] wl0[30] wl0[29] wl0[28] wl0[27] wl0[26] wl0[25] wl0[24]
+ wl0[23] wl0[22] wl0[21] wl0[20] wl0[19] wl0[18] wl0[17] wl0[16] wl0[15] wl0[14]
+ wl0[13] wl0[12] wl0[11] wl0[10] wl0[9] wl0[8] wl0[7] wl0[6] wl0[5] wl0[4] wl0[3]
+ wl0[2] wl0[1] wl0[0] wl1[255] wl1[254] wl1[253] wl1[252] wl1[251] wl1[250] wl1[249]
+ wl1[248] wl1[247] wl1[246] wl1[245] wl1[244] wl1[243] wl1[242] wl1[241] wl1[240]
+ wl1[239] wl1[238] wl1[237] wl1[236] wl1[235] wl1[234] wl1[233] wl1[232] wl1[231]
+ wl1[230] wl1[229] wl1[228] wl1[227] wl1[226] wl1[225] wl1[224] wl1[223] wl1[222]
+ wl1[221] wl1[220] wl1[219] wl1[218] wl1[217] wl1[216] wl1[215] wl1[214] wl1[213]
+ wl1[212] wl1[211] wl1[210] wl1[209] wl1[208] wl1[207] wl1[206] wl1[205] wl1[204]
+ wl1[203] wl1[202] wl1[201] wl1[200] wl1[199] wl1[198] wl1[197] wl1[196] wl1[195]
+ wl1[194] wl1[193] wl1[192] wl1[191] wl1[190] wl1[189] wl1[188] wl1[187] wl1[186]
+ wl1[185] wl1[184] wl1[183] wl1[182] wl1[181] wl1[180] wl1[179] wl1[178] wl1[177]
+ wl1[176] wl1[175] wl1[174] wl1[173] wl1[172] wl1[171] wl1[170] wl1[169] wl1[168]
+ wl1[167] wl1[166] wl1[165] wl1[164] wl1[163] wl1[162] wl1[161] wl1[160] wl1[159]
+ wl1[158] wl1[157] wl1[156] wl1[155] wl1[154] wl1[153] wl1[152] wl1[151] wl1[150]
+ wl1[149] wl1[148] wl1[147] wl1[146] wl1[145] wl1[144] wl1[143] wl1[142] wl1[141]
+ wl1[140] wl1[139] wl1[138] wl1[137] wl1[136] wl1[135] wl1[134] wl1[133] wl1[132]
+ wl1[131] wl1[130] wl1[129] wl1[128] wl1[127] wl1[126] wl1[125] wl1[124] wl1[123]
+ wl1[122] wl1[121] wl1[120] wl1[119] wl1[118] wl1[117] wl1[116] wl1[115] wl1[114]
+ wl1[113] wl1[112] wl1[111] wl1[110] wl1[109] wl1[108] wl1[107] wl1[106] wl1[105]
+ wl1[104] wl1[103] wl1[102] wl1[101] wl1[100] wl1[99] wl1[98] wl1[97] wl1[96] wl1[95]
+ wl1[94] wl1[93] wl1[92] wl1[91] wl1[90] wl1[89] wl1[88] wl1[87] wl1[86] wl1[85]
+ wl1[84] wl1[83] wl1[82] wl1[81] wl1[80] wl1[79] wl1[78] wl1[77] wl1[76] wl1[75]
+ wl1[74] wl1[73] wl1[72] wl1[71] wl1[70] wl1[69] wl1[68] wl1[67] wl1[66] wl1[65]
+ wl1[64] wl1[63] wl1[62] wl1[61] wl1[60] wl1[59] wl1[58] wl1[57] wl1[56] wl1[55]
+ wl1[54] wl1[53] wl1[52] wl1[51] wl1[50] wl1[49] wl1[48] wl1[47] wl1[46] wl1[45]
+ wl1[44] wl1[43] wl1[42] wl1[41] wl1[40] wl1[39] wl1[38] wl1[37] wl1[36] wl1[35]
+ wl1[34] wl1[33] wl1[32] wl1[31] wl1[30] wl1[29] wl1[28] wl1[27] wl1[26] wl1[25]
+ wl1[24] wl1[23] wl1[22] wl1[21] wl1[20] wl1[19] wl1[18] wl1[17] wl1[16] wl1[15]
+ wl1[14] wl1[13] wl1[12] wl1[11] wl1[10] wl1[9] wl1[8] wl1[7] wl1[6] wl1[5] wl1[4]
+ wl1[3] wl1[2] wl1[1] wl1[0] wrclk wrcolsel0[3] wrcolsel0[2] wrcolsel0[1] wrcolsel0[0]
+ wrcolsel1[3] wrcolsel1[2] wrcolsel1[1] wrcolsel1[0] wrdataen ip78d6hcf2sr4096x135m4i2k4w8r2lya_slice
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya_subbnk activered#[1] activered#[0] bankgrant1h
+ clkbank fz_asynckick# fz_asyncrd# fz_asyncwr# fz_finekick#[3] fz_finekick#[2]
+ fz_finekick#[1] fz_finekick#[0] fz_rassel#[2] fz_rassel#[1] fz_rassel#[0] fz_rdwlcut#
+ fz_rdwlpw#[3] fz_rdwlpw#[2] fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw#[1] fz_saepw#[0]
+ fz_trbwassel#[2] fz_trbwassel#[1] fz_trbwassel#[0] fz_trkwllvl#[2] fz_trkwllvl#[1]
+ fz_trkwllvl#[0] fz_wassel#[2] fz_wassel#[1] fz_wassel#[0] fz_wrwlcut# fz_wrwlpw#[1]
+ fz_wrwlpw#[0] grant1l grant2h ia_hi#[2] ia_hi#[1] ia_hi#[0] ia_mid#[2] ia_mid#[1]
+ ia_mid#[0] ia_wle#[1] ia_wle#[0] idin1l[134] idin1l[133] idin1l[132] idin1l[131]
+ idin1l[130] idin1l[129] idin1l[128] idin1l[127] idin1l[126] idin1l[125] idin1l[124]
+ idin1l[123] idin1l[122] idin1l[121] idin1l[120] idin1l[119] idin1l[118] idin1l[117]
+ idin1l[116] idin1l[115] idin1l[114] idin1l[113] idin1l[112] idin1l[111] idin1l[110]
+ idin1l[109] idin1l[108] idin1l[107] idin1l[106] idin1l[105] idin1l[104] idin1l[103]
+ idin1l[102] idin1l[101] idin1l[100] idin1l[99] idin1l[98] idin1l[97] idin1l[96]
+ idin1l[95] idin1l[94] idin1l[93] idin1l[92] idin1l[91] idin1l[90] idin1l[89] idin1l[88]
+ idin1l[87] idin1l[86] idin1l[85] idin1l[84] idin1l[83] idin1l[82] idin1l[81] idin1l[80]
+ idin1l[79] idin1l[78] idin1l[77] idin1l[76] idin1l[75] idin1l[74] idin1l[73] idin1l[72]
+ idin1l[71] idin1l[70] idin1l[69] idin1l[68] idin1l[67] idin1l[66] idin1l[65] idin1l[64]
+ idin1l[63] idin1l[62] idin1l[61] idin1l[60] idin1l[59] idin1l[58] idin1l[57] idin1l[56]
+ idin1l[55] idin1l[54] idin1l[53] idin1l[52] idin1l[51] idin1l[50] idin1l[49] idin1l[48]
+ idin1l[47] idin1l[46] idin1l[45] idin1l[44] idin1l[43] idin1l[42] idin1l[41] idin1l[40]
+ idin1l[39] idin1l[38] idin1l[37] idin1l[36] idin1l[35] idin1l[34] idin1l[33] idin1l[32]
+ idin1l[31] idin1l[30] idin1l[29] idin1l[28] idin1l[27] idin1l[26] idin1l[25] idin1l[24]
+ idin1l[23] idin1l[22] idin1l[21] idin1l[20] idin1l[19] idin1l[18] idin1l[17] idin1l[16]
+ idin1l[15] idin1l[14] idin1l[13] idin1l[12] idin1l[11] idin1l[10] idin1l[9] idin1l[8]
+ idin1l[7] idin1l[6] idin1l[5] idin1l[4] idin1l[3] idin1l[2] idin1l[1] idin1l[0]
+ iwren1h iwren1l2l iwren2h3h lyal0bl[134] lyal0bl[133] lyal0bl[132] lyal0bl[131]
+ lyal0bl[130] lyal0bl[129] lyal0bl[128] lyal0bl[127] lyal0bl[126] lyal0bl[125]
+ lyal0bl[124] lyal0bl[123] lyal0bl[122] lyal0bl[121] lyal0bl[120] lyal0bl[119]
+ lyal0bl[118] lyal0bl[117] lyal0bl[116] lyal0bl[115] lyal0bl[114] lyal0bl[113]
+ lyal0bl[112] lyal0bl[111] lyal0bl[110] lyal0bl[109] lyal0bl[108] lyal0bl[107]
+ lyal0bl[106] lyal0bl[105] lyal0bl[104] lyal0bl[103] lyal0bl[102] lyal0bl[101]
+ lyal0bl[100] lyal0bl[99] lyal0bl[98] lyal0bl[97] lyal0bl[96] lyal0bl[95] lyal0bl[94]
+ lyal0bl[93] lyal0bl[92] lyal0bl[91] lyal0bl[90] lyal0bl[89] lyal0bl[88] lyal0bl[87]
+ lyal0bl[86] lyal0bl[85] lyal0bl[84] lyal0bl[83] lyal0bl[82] lyal0bl[81] lyal0bl[80]
+ lyal0bl[79] lyal0bl[78] lyal0bl[77] lyal0bl[76] lyal0bl[75] lyal0bl[74] lyal0bl[73]
+ lyal0bl[72] lyal0bl[71] lyal0bl[70] lyal0bl[69] lyal0bl[68] lyal0bl[67] lyal0bl[66]
+ lyal0bl[65] lyal0bl[64] lyal0bl[63] lyal0bl[62] lyal0bl[61] lyal0bl[60] lyal0bl[59]
+ lyal0bl[58] lyal0bl[57] lyal0bl[56] lyal0bl[55] lyal0bl[54] lyal0bl[53] lyal0bl[52]
+ lyal0bl[51] lyal0bl[50] lyal0bl[49] lyal0bl[48] lyal0bl[47] lyal0bl[46] lyal0bl[45]
+ lyal0bl[44] lyal0bl[43] lyal0bl[42] lyal0bl[41] lyal0bl[40] lyal0bl[39] lyal0bl[38]
+ lyal0bl[37] lyal0bl[36] lyal0bl[35] lyal0bl[34] lyal0bl[33] lyal0bl[32] lyal0bl[31]
+ lyal0bl[30] lyal0bl[29] lyal0bl[28] lyal0bl[27] lyal0bl[26] lyal0bl[25] lyal0bl[24]
+ lyal0bl[23] lyal0bl[22] lyal0bl[21] lyal0bl[20] lyal0bl[19] lyal0bl[18] lyal0bl[17]
+ lyal0bl[16] lyal0bl[15] lyal0bl[14] lyal0bl[13] lyal0bl[12] lyal0bl[11] lyal0bl[10]
+ lyal0bl[9] lyal0bl[8] lyal0bl[7] lyal0bl[6] lyal0bl[5] lyal0bl[4] lyal0bl[3] lyal0bl[2]
+ lyal0bl[1] lyal0bl[0] lyal0blnn[134] lyal0blnn[133] lyal0blnn[132] lyal0blnn[131]
+ lyal0blnn[130] lyal0blnn[129] lyal0blnn[128] lyal0blnn[127] lyal0blnn[126] lyal0blnn[125]
+ lyal0blnn[124] lyal0blnn[123] lyal0blnn[122] lyal0blnn[121] lyal0blnn[120] lyal0blnn[119]
+ lyal0blnn[118] lyal0blnn[117] lyal0blnn[116] lyal0blnn[115] lyal0blnn[114] lyal0blnn[113]
+ lyal0blnn[112] lyal0blnn[111] lyal0blnn[110] lyal0blnn[109] lyal0blnn[108] lyal0blnn[107]
+ lyal0blnn[106] lyal0blnn[105] lyal0blnn[104] lyal0blnn[103] lyal0blnn[102] lyal0blnn[101]
+ lyal0blnn[100] lyal0blnn[99] lyal0blnn[98] lyal0blnn[97] lyal0blnn[96] lyal0blnn[95]
+ lyal0blnn[94] lyal0blnn[93] lyal0blnn[92] lyal0blnn[91] lyal0blnn[90] lyal0blnn[89]
+ lyal0blnn[88] lyal0blnn[87] lyal0blnn[86] lyal0blnn[85] lyal0blnn[84] lyal0blnn[83]
+ lyal0blnn[82] lyal0blnn[81] lyal0blnn[80] lyal0blnn[79] lyal0blnn[78] lyal0blnn[77]
+ lyal0blnn[76] lyal0blnn[75] lyal0blnn[74] lyal0blnn[73] lyal0blnn[72] lyal0blnn[71]
+ lyal0blnn[70] lyal0blnn[69] lyal0blnn[68] lyal0blnn[67] lyal0blnn[66] lyal0blnn[65]
+ lyal0blnn[64] lyal0blnn[63] lyal0blnn[62] lyal0blnn[61] lyal0blnn[60] lyal0blnn[59]
+ lyal0blnn[58] lyal0blnn[57] lyal0blnn[56] lyal0blnn[55] lyal0blnn[54] lyal0blnn[53]
+ lyal0blnn[52] lyal0blnn[51] lyal0blnn[50] lyal0blnn[49] lyal0blnn[48] lyal0blnn[47]
+ lyal0blnn[46] lyal0blnn[45] lyal0blnn[44] lyal0blnn[43] lyal0blnn[42] lyal0blnn[41]
+ lyal0blnn[40] lyal0blnn[39] lyal0blnn[38] lyal0blnn[37] lyal0blnn[36] lyal0blnn[35]
+ lyal0blnn[34] lyal0blnn[33] lyal0blnn[32] lyal0blnn[31] lyal0blnn[30] lyal0blnn[29]
+ lyal0blnn[28] lyal0blnn[27] lyal0blnn[26] lyal0blnn[25] lyal0blnn[24] lyal0blnn[23]
+ lyal0blnn[22] lyal0blnn[21] lyal0blnn[20] lyal0blnn[19] lyal0blnn[18] lyal0blnn[17]
+ lyal0blnn[16] lyal0blnn[15] lyal0blnn[14] lyal0blnn[13] lyal0blnn[12] lyal0blnn[11]
+ lyal0blnn[10] lyal0blnn[9] lyal0blnn[8] lyal0blnn[7] lyal0blnn[6] lyal0blnn[5]
+ lyal0blnn[4] lyal0blnn[3] lyal0blnn[2] lyal0blnn[1] lyal0blnn[0] lyanowl# lyasel
+ rddataout[134] rddataout[133] rddataout[132] rddataout[131] rddataout[130] rddataout[129]
+ rddataout[128] rddataout[127] rddataout[126] rddataout[125] rddataout[124] rddataout[123]
+ rddataout[122] rddataout[121] rddataout[120] rddataout[119] rddataout[118] rddataout[117]
+ rddataout[116] rddataout[115] rddataout[114] rddataout[113] rddataout[112] rddataout[111]
+ rddataout[110] rddataout[109] rddataout[108] rddataout[107] rddataout[106] rddataout[105]
+ rddataout[104] rddataout[103] rddataout[102] rddataout[101] rddataout[100] rddataout[99]
+ rddataout[98] rddataout[97] rddataout[96] rddataout[95] rddataout[94] rddataout[93]
+ rddataout[92] rddataout[91] rddataout[90] rddataout[89] rddataout[88] rddataout[87]
+ rddataout[86] rddataout[85] rddataout[84] rddataout[83] rddataout[82] rddataout[81]
+ rddataout[80] rddataout[79] rddataout[78] rddataout[77] rddataout[76] rddataout[75]
+ rddataout[74] rddataout[73] rddataout[72] rddataout[71] rddataout[70] rddataout[69]
+ rddataout[68] rddataout[67] rddataout[66] rddataout[65] rddataout[64] rddataout[63]
+ rddataout[62] rddataout[61] rddataout[60] rddataout[59] rddataout[58] rddataout[57]
+ rddataout[56] rddataout[55] rddataout[54] rddataout[53] rddataout[52] rddataout[51]
+ rddataout[50] rddataout[49] rddataout[48] rddataout[47] rddataout[46] rddataout[45]
+ rddataout[44] rddataout[43] rddataout[42] rddataout[41] rddataout[40] rddataout[39]
+ rddataout[38] rddataout[37] rddataout[36] rddataout[35] rddataout[34] rddataout[33]
+ rddataout[32] rddataout[31] rddataout[30] rddataout[29] rddataout[28] rddataout[27]
+ rddataout[26] rddataout[25] rddataout[24] rddataout[23] rddataout[22] rddataout[21]
+ rddataout[20] rddataout[19] rddataout[18] rddataout[17] rddataout[16] rddataout[15]
+ rddataout[14] rddataout[13] rddataout[12] rddataout[11] rddataout[10] rddataout[9]
+ rddataout[8] rddataout[7] rddataout[6] rddataout[5] rddataout[4] rddataout[3]
+ rddataout[2] rddataout[1] rddataout[0] sideen[0] turbomode# vcc vss wayselbnk[3]
+ wayselbnk[2] wayselbnk[1] wayselbnk[0]
*.PININFO activered#[1]:I activered#[0]:I bankgrant1h:I clkbank:I fz_asynckick#:I fz_asyncrd#:I fz_asyncwr#:I fz_finekick#[3]:I fz_finekick#[2]:I fz_finekick#[1]:I fz_finekick#[0]:I fz_rassel#[2]:I fz_rassel#[1]:I fz_rassel#[0]:I fz_rdwlcut#:I fz_rdwlpw#[3]:I fz_rdwlpw#[2]:I fz_rdwlpw#[1]:I fz_rdwlpw#[0]:I fz_saepw#[1]:I
*.PININFO fz_saepw#[0]:I fz_trbwassel#[2]:I fz_trbwassel#[1]:I fz_trbwassel#[0]:I fz_trkwllvl#[2]:I fz_trkwllvl#[1]:I fz_trkwllvl#[0]:I fz_wassel#[2]:I fz_wassel#[1]:I fz_wassel#[0]:I fz_wrwlcut#:I fz_wrwlpw#[1]:I fz_wrwlpw#[0]:I grant1l:I grant2h:I ia_hi#[2]:I ia_hi#[1]:I ia_hi#[0]:I ia_mid#[2]:I ia_mid#[1]:I
*.PININFO ia_mid#[0]:I ia_wle#[1]:I ia_wle#[0]:I idin1l[134]:I idin1l[133]:I idin1l[132]:I idin1l[131]:I idin1l[130]:I idin1l[129]:I idin1l[128]:I idin1l[127]:I idin1l[126]:I idin1l[125]:I idin1l[124]:I idin1l[123]:I idin1l[122]:I idin1l[121]:I idin1l[120]:I idin1l[119]:I idin1l[118]:I
*.PININFO idin1l[117]:I idin1l[116]:I idin1l[115]:I idin1l[114]:I idin1l[113]:I idin1l[112]:I idin1l[111]:I idin1l[110]:I idin1l[109]:I idin1l[108]:I idin1l[107]:I idin1l[106]:I idin1l[105]:I idin1l[104]:I idin1l[103]:I idin1l[102]:I idin1l[101]:I idin1l[100]:I idin1l[99]:I idin1l[98]:I
*.PININFO idin1l[97]:I idin1l[96]:I idin1l[95]:I idin1l[94]:I idin1l[93]:I idin1l[92]:I idin1l[91]:I idin1l[90]:I idin1l[89]:I idin1l[88]:I idin1l[87]:I idin1l[86]:I idin1l[85]:I idin1l[84]:I idin1l[83]:I idin1l[82]:I idin1l[81]:I idin1l[80]:I idin1l[79]:I idin1l[78]:I
*.PININFO idin1l[77]:I idin1l[76]:I idin1l[75]:I idin1l[74]:I idin1l[73]:I idin1l[72]:I idin1l[71]:I idin1l[70]:I idin1l[69]:I idin1l[68]:I idin1l[67]:I idin1l[66]:I idin1l[65]:I idin1l[64]:I idin1l[63]:I idin1l[62]:I idin1l[61]:I idin1l[60]:I idin1l[59]:I idin1l[58]:I
*.PININFO idin1l[57]:I idin1l[56]:I idin1l[55]:I idin1l[54]:I idin1l[53]:I idin1l[52]:I idin1l[51]:I idin1l[50]:I idin1l[49]:I idin1l[48]:I idin1l[47]:I idin1l[46]:I idin1l[45]:I idin1l[44]:I idin1l[43]:I idin1l[42]:I idin1l[41]:I idin1l[40]:I idin1l[39]:I idin1l[38]:I
*.PININFO idin1l[37]:I idin1l[36]:I idin1l[35]:I idin1l[34]:I idin1l[33]:I idin1l[32]:I idin1l[31]:I idin1l[30]:I idin1l[29]:I idin1l[28]:I idin1l[27]:I idin1l[26]:I idin1l[25]:I idin1l[24]:I idin1l[23]:I idin1l[22]:I idin1l[21]:I idin1l[20]:I idin1l[19]:I idin1l[18]:I
*.PININFO idin1l[17]:I idin1l[16]:I idin1l[15]:I idin1l[14]:I idin1l[13]:I idin1l[12]:I idin1l[11]:I idin1l[10]:I idin1l[9]:I idin1l[8]:I idin1l[7]:I idin1l[6]:I idin1l[5]:I idin1l[4]:I idin1l[3]:I idin1l[2]:I idin1l[1]:I idin1l[0]:I iwren1h:I iwren1l2l:I
*.PININFO iwren2h3h:I lyal0bl[134]:I lyal0bl[133]:I lyal0bl[132]:I lyal0bl[131]:I lyal0bl[130]:I lyal0bl[129]:I lyal0bl[128]:I lyal0bl[127]:I lyal0bl[126]:I lyal0bl[125]:I lyal0bl[124]:I lyal0bl[123]:I lyal0bl[122]:I lyal0bl[121]:I lyal0bl[120]:I lyal0bl[119]:I lyal0bl[118]:I lyal0bl[117]:I lyal0bl[116]:I
*.PININFO lyal0bl[115]:I lyal0bl[114]:I lyal0bl[113]:I lyal0bl[112]:I lyal0bl[111]:I lyal0bl[110]:I lyal0bl[109]:I lyal0bl[108]:I lyal0bl[107]:I lyal0bl[106]:I lyal0bl[105]:I lyal0bl[104]:I lyal0bl[103]:I lyal0bl[102]:I lyal0bl[101]:I lyal0bl[100]:I lyal0bl[99]:I lyal0bl[98]:I lyal0bl[97]:I lyal0bl[96]:I
*.PININFO lyal0bl[95]:I lyal0bl[94]:I lyal0bl[93]:I lyal0bl[92]:I lyal0bl[91]:I lyal0bl[90]:I lyal0bl[89]:I lyal0bl[88]:I lyal0bl[87]:I lyal0bl[86]:I lyal0bl[85]:I lyal0bl[84]:I lyal0bl[83]:I lyal0bl[82]:I lyal0bl[81]:I lyal0bl[80]:I lyal0bl[79]:I lyal0bl[78]:I lyal0bl[77]:I lyal0bl[76]:I
*.PININFO lyal0bl[75]:I lyal0bl[74]:I lyal0bl[73]:I lyal0bl[72]:I lyal0bl[71]:I lyal0bl[70]:I lyal0bl[69]:I lyal0bl[68]:I lyal0bl[67]:I lyal0bl[66]:I lyal0bl[65]:I lyal0bl[64]:I lyal0bl[63]:I lyal0bl[62]:I lyal0bl[61]:I lyal0bl[60]:I lyal0bl[59]:I lyal0bl[58]:I lyal0bl[57]:I lyal0bl[56]:I
*.PININFO lyal0bl[55]:I lyal0bl[54]:I lyal0bl[53]:I lyal0bl[52]:I lyal0bl[51]:I lyal0bl[50]:I lyal0bl[49]:I lyal0bl[48]:I lyal0bl[47]:I lyal0bl[46]:I lyal0bl[45]:I lyal0bl[44]:I lyal0bl[43]:I lyal0bl[42]:I lyal0bl[41]:I lyal0bl[40]:I lyal0bl[39]:I lyal0bl[38]:I lyal0bl[37]:I lyal0bl[36]:I
*.PININFO lyal0bl[35]:I lyal0bl[34]:I lyal0bl[33]:I lyal0bl[32]:I lyal0bl[31]:I lyal0bl[30]:I lyal0bl[29]:I lyal0bl[28]:I lyal0bl[27]:I lyal0bl[26]:I lyal0bl[25]:I lyal0bl[24]:I lyal0bl[23]:I lyal0bl[22]:I lyal0bl[21]:I lyal0bl[20]:I lyal0bl[19]:I lyal0bl[18]:I lyal0bl[17]:I lyal0bl[16]:I
*.PININFO lyal0bl[15]:I lyal0bl[14]:I lyal0bl[13]:I lyal0bl[12]:I lyal0bl[11]:I lyal0bl[10]:I lyal0bl[9]:I lyal0bl[8]:I lyal0bl[7]:I lyal0bl[6]:I lyal0bl[5]:I lyal0bl[4]:I lyal0bl[3]:I lyal0bl[2]:I lyal0bl[1]:I lyal0bl[0]:I lyal0blnn[134]:I lyal0blnn[133]:I lyal0blnn[132]:I lyal0blnn[131]:I
*.PININFO lyal0blnn[130]:I lyal0blnn[129]:I lyal0blnn[128]:I lyal0blnn[127]:I lyal0blnn[126]:I lyal0blnn[125]:I lyal0blnn[124]:I lyal0blnn[123]:I lyal0blnn[122]:I lyal0blnn[121]:I lyal0blnn[120]:I lyal0blnn[119]:I lyal0blnn[118]:I lyal0blnn[117]:I lyal0blnn[116]:I lyal0blnn[115]:I lyal0blnn[114]:I lyal0blnn[113]:I lyal0blnn[112]:I lyal0blnn[111]:I
*.PININFO lyal0blnn[110]:I lyal0blnn[109]:I lyal0blnn[108]:I lyal0blnn[107]:I lyal0blnn[106]:I lyal0blnn[105]:I lyal0blnn[104]:I lyal0blnn[103]:I lyal0blnn[102]:I lyal0blnn[101]:I lyal0blnn[100]:I lyal0blnn[99]:I lyal0blnn[98]:I lyal0blnn[97]:I lyal0blnn[96]:I lyal0blnn[95]:I lyal0blnn[94]:I lyal0blnn[93]:I lyal0blnn[92]:I lyal0blnn[91]:I
*.PININFO lyal0blnn[90]:I lyal0blnn[89]:I lyal0blnn[88]:I lyal0blnn[87]:I lyal0blnn[86]:I lyal0blnn[85]:I lyal0blnn[84]:I lyal0blnn[83]:I lyal0blnn[82]:I lyal0blnn[81]:I lyal0blnn[80]:I lyal0blnn[79]:I lyal0blnn[78]:I lyal0blnn[77]:I lyal0blnn[76]:I lyal0blnn[75]:I lyal0blnn[74]:I lyal0blnn[73]:I lyal0blnn[72]:I lyal0blnn[71]:I
*.PININFO lyal0blnn[70]:I lyal0blnn[69]:I lyal0blnn[68]:I lyal0blnn[67]:I lyal0blnn[66]:I lyal0blnn[65]:I lyal0blnn[64]:I lyal0blnn[63]:I lyal0blnn[62]:I lyal0blnn[61]:I lyal0blnn[60]:I lyal0blnn[59]:I lyal0blnn[58]:I lyal0blnn[57]:I lyal0blnn[56]:I lyal0blnn[55]:I lyal0blnn[54]:I lyal0blnn[53]:I lyal0blnn[52]:I lyal0blnn[51]:I
*.PININFO lyal0blnn[50]:I lyal0blnn[49]:I lyal0blnn[48]:I lyal0blnn[47]:I lyal0blnn[46]:I lyal0blnn[45]:I lyal0blnn[44]:I lyal0blnn[43]:I lyal0blnn[42]:I lyal0blnn[41]:I lyal0blnn[40]:I lyal0blnn[39]:I lyal0blnn[38]:I lyal0blnn[37]:I lyal0blnn[36]:I lyal0blnn[35]:I lyal0blnn[34]:I lyal0blnn[33]:I lyal0blnn[32]:I lyal0blnn[31]:I
*.PININFO lyal0blnn[30]:I lyal0blnn[29]:I lyal0blnn[28]:I lyal0blnn[27]:I lyal0blnn[26]:I lyal0blnn[25]:I lyal0blnn[24]:I lyal0blnn[23]:I lyal0blnn[22]:I lyal0blnn[21]:I lyal0blnn[20]:I lyal0blnn[19]:I lyal0blnn[18]:I lyal0blnn[17]:I lyal0blnn[16]:I lyal0blnn[15]:I lyal0blnn[14]:I lyal0blnn[13]:I lyal0blnn[12]:I lyal0blnn[11]:I
*.PININFO lyal0blnn[10]:I lyal0blnn[9]:I lyal0blnn[8]:I lyal0blnn[7]:I lyal0blnn[6]:I lyal0blnn[5]:I lyal0blnn[4]:I lyal0blnn[3]:I lyal0blnn[2]:I lyal0blnn[1]:I lyal0blnn[0]:I lyanowl#:I lyasel:I rddataout[134]:O rddataout[133]:O rddataout[132]:O rddataout[131]:O rddataout[130]:O rddataout[129]:O rddataout[128]:O
*.PININFO rddataout[127]:O rddataout[126]:O rddataout[125]:O rddataout[124]:O rddataout[123]:O rddataout[122]:O rddataout[121]:O rddataout[120]:O rddataout[119]:O rddataout[118]:O rddataout[117]:O rddataout[116]:O rddataout[115]:O rddataout[114]:O rddataout[113]:O rddataout[112]:O rddataout[111]:O rddataout[110]:O rddataout[109]:O rddataout[108]:O
*.PININFO rddataout[107]:O rddataout[106]:O rddataout[105]:O rddataout[104]:O rddataout[103]:O rddataout[102]:O rddataout[101]:O rddataout[100]:O rddataout[99]:O rddataout[98]:O rddataout[97]:O rddataout[96]:O rddataout[95]:O rddataout[94]:O rddataout[93]:O rddataout[92]:O rddataout[91]:O rddataout[90]:O rddataout[89]:O rddataout[88]:O
*.PININFO rddataout[87]:O rddataout[86]:O rddataout[85]:O rddataout[84]:O rddataout[83]:O rddataout[82]:O rddataout[81]:O rddataout[80]:O rddataout[79]:O rddataout[78]:O rddataout[77]:O rddataout[76]:O rddataout[75]:O rddataout[74]:O rddataout[73]:O rddataout[72]:O rddataout[71]:O rddataout[70]:O rddataout[69]:O rddataout[68]:O
*.PININFO rddataout[67]:O rddataout[66]:O rddataout[65]:O rddataout[64]:O rddataout[63]:O rddataout[62]:O rddataout[61]:O rddataout[60]:O rddataout[59]:O rddataout[58]:O rddataout[57]:O rddataout[56]:O rddataout[55]:O rddataout[54]:O rddataout[53]:O rddataout[52]:O rddataout[51]:O rddataout[50]:O rddataout[49]:O rddataout[48]:O
*.PININFO rddataout[47]:O rddataout[46]:O rddataout[45]:O rddataout[44]:O rddataout[43]:O rddataout[42]:O rddataout[41]:O rddataout[40]:O rddataout[39]:O rddataout[38]:O rddataout[37]:O rddataout[36]:O rddataout[35]:O rddataout[34]:O rddataout[33]:O rddataout[32]:O rddataout[31]:O rddataout[30]:O rddataout[29]:O rddataout[28]:O
*.PININFO rddataout[27]:O rddataout[26]:O rddataout[25]:O rddataout[24]:O rddataout[23]:O rddataout[22]:O rddataout[21]:O rddataout[20]:O rddataout[19]:O rddataout[18]:O rddataout[17]:O rddataout[16]:O rddataout[15]:O rddataout[14]:O rddataout[13]:O rddataout[12]:O rddataout[11]:O rddataout[10]:O rddataout[9]:O rddataout[8]:O
*.PININFO rddataout[7]:O rddataout[6]:O rddataout[5]:O rddataout[4]:O rddataout[3]:O rddataout[2]:O rddataout[1]:O rddataout[0]:O sideen[0]:I turbomode#:I vcc:I vss:I wayselbnk[3]:I wayselbnk[2]:I wayselbnk[1]:I wayselbnk[0]:I
Xsramcntrl activered#[1] activered#[0] bankgrant1h clkbank clkwrsynckicknn finekick[3]
+ finekick[2] finekick[1] finekick[0] fz_asynckick# fz_asyncrd# fz_asyncwr# fz_finekick#[3]
+ fz_finekick#[2] fz_finekick#[1] fz_finekick#[0] fz_rassel#[2] fz_rassel#[1] fz_rassel#[0]
+ fz_rdwlcut# fz_rdwlpw#[3] fz_rdwlpw#[2] fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw#[1]
+ fz_saepw#[0] fz_synckick fz_syncrd fz_syncwr fz_trbwassel#[2] fz_trbwassel#[1]
+ fz_trbwassel#[0] fz_trkwllvl#[2] fz_trkwllvl#[1] fz_trkwllvl#[0] fz_wassel#[2]
+ fz_wassel#[1] fz_wassel#[0] fz_wrwlcut# fz_wrwlpw#[1] fz_wrwlpw#[0] grant1l grant2h
+ ia_hi#[2] ia_hi#[1] ia_hi#[0] ia_mid#[2] ia_mid#[1] ia_mid#[0] ia_wle#[1] ia_wle#[0]
+ iwren1h iwren1l2l iwren2h3h lyaennn lyanowl# lyasel nbl_kicknn_dn nbl_kicknn_up
+ nblkick pcnn0_dn pcnn0_up pcnn1_dn pcnn1_up rdwl rdwlclkmx rdwlpw[3] rdwlpw[2]
+ rdwlpw[1] rdwlpw[0] rdysel0_dn[3] rdysel0_dn[2] rdysel0_dn[1] rdysel0_dn[0] rdysel0_up[3]
+ rdysel0_up[2] rdysel0_up[1] rdysel0_up[0] rdysel1_dn[3] rdysel1_dn[2] rdysel1_dn[1]
+ rdysel1_dn[0] rdysel1_up[3] rdysel1_up[2] rdysel1_up[1] rdysel1_up[0] redwl0_dn[1]
+ redwl0_dn[0] redwl0_up[1] redwl0_up[0] redwl1_dn[1] redwl1_dn[0] redwl1_up[1]
+ redwl1_up[0] saenn_dn saenn_up sapchnn_dn sapchnn_up sideen[0] trkwllvlnn[2] trkwllvlnn[1]
+ trkwllvlnn[0] turbomode# vcc vss waenn_dn[2] waenn_dn[1] waenn_dn[0] waenn_up[2]
+ waenn_up[1] waenn_up[0] wayselbnk[3] wayselbnk[2] wayselbnk[1] wayselbnk[0] wl0_dn[255]
+ wl0_dn[254] wl0_dn[253] wl0_dn[252] wl0_dn[251] wl0_dn[250] wl0_dn[249] wl0_dn[248]
+ wl0_dn[247] wl0_dn[246] wl0_dn[245] wl0_dn[244] wl0_dn[243] wl0_dn[242] wl0_dn[241]
+ wl0_dn[240] wl0_dn[239] wl0_dn[238] wl0_dn[237] wl0_dn[236] wl0_dn[235] wl0_dn[234]
+ wl0_dn[233] wl0_dn[232] wl0_dn[231] wl0_dn[230] wl0_dn[229] wl0_dn[228] wl0_dn[227]
+ wl0_dn[226] wl0_dn[225] wl0_dn[224] wl0_dn[223] wl0_dn[222] wl0_dn[221] wl0_dn[220]
+ wl0_dn[219] wl0_dn[218] wl0_dn[217] wl0_dn[216] wl0_dn[215] wl0_dn[214] wl0_dn[213]
+ wl0_dn[212] wl0_dn[211] wl0_dn[210] wl0_dn[209] wl0_dn[208] wl0_dn[207] wl0_dn[206]
+ wl0_dn[205] wl0_dn[204] wl0_dn[203] wl0_dn[202] wl0_dn[201] wl0_dn[200] wl0_dn[199]
+ wl0_dn[198] wl0_dn[197] wl0_dn[196] wl0_dn[195] wl0_dn[194] wl0_dn[193] wl0_dn[192]
+ wl0_dn[191] wl0_dn[190] wl0_dn[189] wl0_dn[188] wl0_dn[187] wl0_dn[186] wl0_dn[185]
+ wl0_dn[184] wl0_dn[183] wl0_dn[182] wl0_dn[181] wl0_dn[180] wl0_dn[179] wl0_dn[178]
+ wl0_dn[177] wl0_dn[176] wl0_dn[175] wl0_dn[174] wl0_dn[173] wl0_dn[172] wl0_dn[171]
+ wl0_dn[170] wl0_dn[169] wl0_dn[168] wl0_dn[167] wl0_dn[166] wl0_dn[165] wl0_dn[164]
+ wl0_dn[163] wl0_dn[162] wl0_dn[161] wl0_dn[160] wl0_dn[159] wl0_dn[158] wl0_dn[157]
+ wl0_dn[156] wl0_dn[155] wl0_dn[154] wl0_dn[153] wl0_dn[152] wl0_dn[151] wl0_dn[150]
+ wl0_dn[149] wl0_dn[148] wl0_dn[147] wl0_dn[146] wl0_dn[145] wl0_dn[144] wl0_dn[143]
+ wl0_dn[142] wl0_dn[141] wl0_dn[140] wl0_dn[139] wl0_dn[138] wl0_dn[137] wl0_dn[136]
+ wl0_dn[135] wl0_dn[134] wl0_dn[133] wl0_dn[132] wl0_dn[131] wl0_dn[130] wl0_dn[129]
+ wl0_dn[128] wl0_dn[127] wl0_dn[126] wl0_dn[125] wl0_dn[124] wl0_dn[123] wl0_dn[122]
+ wl0_dn[121] wl0_dn[120] wl0_dn[119] wl0_dn[118] wl0_dn[117] wl0_dn[116] wl0_dn[115]
+ wl0_dn[114] wl0_dn[113] wl0_dn[112] wl0_dn[111] wl0_dn[110] wl0_dn[109] wl0_dn[108]
+ wl0_dn[107] wl0_dn[106] wl0_dn[105] wl0_dn[104] wl0_dn[103] wl0_dn[102] wl0_dn[101]
+ wl0_dn[100] wl0_dn[99] wl0_dn[98] wl0_dn[97] wl0_dn[96] wl0_dn[95] wl0_dn[94]
+ wl0_dn[93] wl0_dn[92] wl0_dn[91] wl0_dn[90] wl0_dn[89] wl0_dn[88] wl0_dn[87] wl0_dn[86]
+ wl0_dn[85] wl0_dn[84] wl0_dn[83] wl0_dn[82] wl0_dn[81] wl0_dn[80] wl0_dn[79] wl0_dn[78]
+ wl0_dn[77] wl0_dn[76] wl0_dn[75] wl0_dn[74] wl0_dn[73] wl0_dn[72] wl0_dn[71] wl0_dn[70]
+ wl0_dn[69] wl0_dn[68] wl0_dn[67] wl0_dn[66] wl0_dn[65] wl0_dn[64] wl0_dn[63] wl0_dn[62]
+ wl0_dn[61] wl0_dn[60] wl0_dn[59] wl0_dn[58] wl0_dn[57] wl0_dn[56] wl0_dn[55] wl0_dn[54]
+ wl0_dn[53] wl0_dn[52] wl0_dn[51] wl0_dn[50] wl0_dn[49] wl0_dn[48] wl0_dn[47] wl0_dn[46]
+ wl0_dn[45] wl0_dn[44] wl0_dn[43] wl0_dn[42] wl0_dn[41] wl0_dn[40] wl0_dn[39] wl0_dn[38]
+ wl0_dn[37] wl0_dn[36] wl0_dn[35] wl0_dn[34] wl0_dn[33] wl0_dn[32] wl0_dn[31] wl0_dn[30]
+ wl0_dn[29] wl0_dn[28] wl0_dn[27] wl0_dn[26] wl0_dn[25] wl0_dn[24] wl0_dn[23] wl0_dn[22]
+ wl0_dn[21] wl0_dn[20] wl0_dn[19] wl0_dn[18] wl0_dn[17] wl0_dn[16] wl0_dn[15] wl0_dn[14]
+ wl0_dn[13] wl0_dn[12] wl0_dn[11] wl0_dn[10] wl0_dn[9] wl0_dn[8] wl0_dn[7] wl0_dn[6]
+ wl0_dn[5] wl0_dn[4] wl0_dn[3] wl0_dn[2] wl0_dn[1] wl0_dn[0] wl0_up[255] wl0_up[254]
+ wl0_up[253] wl0_up[252] wl0_up[251] wl0_up[250] wl0_up[249] wl0_up[248] wl0_up[247]
+ wl0_up[246] wl0_up[245] wl0_up[244] wl0_up[243] wl0_up[242] wl0_up[241] wl0_up[240]
+ wl0_up[239] wl0_up[238] wl0_up[237] wl0_up[236] wl0_up[235] wl0_up[234] wl0_up[233]
+ wl0_up[232] wl0_up[231] wl0_up[230] wl0_up[229] wl0_up[228] wl0_up[227] wl0_up[226]
+ wl0_up[225] wl0_up[224] wl0_up[223] wl0_up[222] wl0_up[221] wl0_up[220] wl0_up[219]
+ wl0_up[218] wl0_up[217] wl0_up[216] wl0_up[215] wl0_up[214] wl0_up[213] wl0_up[212]
+ wl0_up[211] wl0_up[210] wl0_up[209] wl0_up[208] wl0_up[207] wl0_up[206] wl0_up[205]
+ wl0_up[204] wl0_up[203] wl0_up[202] wl0_up[201] wl0_up[200] wl0_up[199] wl0_up[198]
+ wl0_up[197] wl0_up[196] wl0_up[195] wl0_up[194] wl0_up[193] wl0_up[192] wl0_up[191]
+ wl0_up[190] wl0_up[189] wl0_up[188] wl0_up[187] wl0_up[186] wl0_up[185] wl0_up[184]
+ wl0_up[183] wl0_up[182] wl0_up[181] wl0_up[180] wl0_up[179] wl0_up[178] wl0_up[177]
+ wl0_up[176] wl0_up[175] wl0_up[174] wl0_up[173] wl0_up[172] wl0_up[171] wl0_up[170]
+ wl0_up[169] wl0_up[168] wl0_up[167] wl0_up[166] wl0_up[165] wl0_up[164] wl0_up[163]
+ wl0_up[162] wl0_up[161] wl0_up[160] wl0_up[159] wl0_up[158] wl0_up[157] wl0_up[156]
+ wl0_up[155] wl0_up[154] wl0_up[153] wl0_up[152] wl0_up[151] wl0_up[150] wl0_up[149]
+ wl0_up[148] wl0_up[147] wl0_up[146] wl0_up[145] wl0_up[144] wl0_up[143] wl0_up[142]
+ wl0_up[141] wl0_up[140] wl0_up[139] wl0_up[138] wl0_up[137] wl0_up[136] wl0_up[135]
+ wl0_up[134] wl0_up[133] wl0_up[132] wl0_up[131] wl0_up[130] wl0_up[129] wl0_up[128]
+ wl0_up[127] wl0_up[126] wl0_up[125] wl0_up[124] wl0_up[123] wl0_up[122] wl0_up[121]
+ wl0_up[120] wl0_up[119] wl0_up[118] wl0_up[117] wl0_up[116] wl0_up[115] wl0_up[114]
+ wl0_up[113] wl0_up[112] wl0_up[111] wl0_up[110] wl0_up[109] wl0_up[108] wl0_up[107]
+ wl0_up[106] wl0_up[105] wl0_up[104] wl0_up[103] wl0_up[102] wl0_up[101] wl0_up[100]
+ wl0_up[99] wl0_up[98] wl0_up[97] wl0_up[96] wl0_up[95] wl0_up[94] wl0_up[93] wl0_up[92]
+ wl0_up[91] wl0_up[90] wl0_up[89] wl0_up[88] wl0_up[87] wl0_up[86] wl0_up[85] wl0_up[84]
+ wl0_up[83] wl0_up[82] wl0_up[81] wl0_up[80] wl0_up[79] wl0_up[78] wl0_up[77] wl0_up[76]
+ wl0_up[75] wl0_up[74] wl0_up[73] wl0_up[72] wl0_up[71] wl0_up[70] wl0_up[69] wl0_up[68]
+ wl0_up[67] wl0_up[66] wl0_up[65] wl0_up[64] wl0_up[63] wl0_up[62] wl0_up[61] wl0_up[60]
+ wl0_up[59] wl0_up[58] wl0_up[57] wl0_up[56] wl0_up[55] wl0_up[54] wl0_up[53] wl0_up[52]
+ wl0_up[51] wl0_up[50] wl0_up[49] wl0_up[48] wl0_up[47] wl0_up[46] wl0_up[45] wl0_up[44]
+ wl0_up[43] wl0_up[42] wl0_up[41] wl0_up[40] wl0_up[39] wl0_up[38] wl0_up[37] wl0_up[36]
+ wl0_up[35] wl0_up[34] wl0_up[33] wl0_up[32] wl0_up[31] wl0_up[30] wl0_up[29] wl0_up[28]
+ wl0_up[27] wl0_up[26] wl0_up[25] wl0_up[24] wl0_up[23] wl0_up[22] wl0_up[21] wl0_up[20]
+ wl0_up[19] wl0_up[18] wl0_up[17] wl0_up[16] wl0_up[15] wl0_up[14] wl0_up[13] wl0_up[12]
+ wl0_up[11] wl0_up[10] wl0_up[9] wl0_up[8] wl0_up[7] wl0_up[6] wl0_up[5] wl0_up[4]
+ wl0_up[3] wl0_up[2] wl0_up[1] wl0_up[0] wl1_dn[255] wl1_dn[254] wl1_dn[253] wl1_dn[252]
+ wl1_dn[251] wl1_dn[250] wl1_dn[249] wl1_dn[248] wl1_dn[247] wl1_dn[246] wl1_dn[245]
+ wl1_dn[244] wl1_dn[243] wl1_dn[242] wl1_dn[241] wl1_dn[240] wl1_dn[239] wl1_dn[238]
+ wl1_dn[237] wl1_dn[236] wl1_dn[235] wl1_dn[234] wl1_dn[233] wl1_dn[232] wl1_dn[231]
+ wl1_dn[230] wl1_dn[229] wl1_dn[228] wl1_dn[227] wl1_dn[226] wl1_dn[225] wl1_dn[224]
+ wl1_dn[223] wl1_dn[222] wl1_dn[221] wl1_dn[220] wl1_dn[219] wl1_dn[218] wl1_dn[217]
+ wl1_dn[216] wl1_dn[215] wl1_dn[214] wl1_dn[213] wl1_dn[212] wl1_dn[211] wl1_dn[210]
+ wl1_dn[209] wl1_dn[208] wl1_dn[207] wl1_dn[206] wl1_dn[205] wl1_dn[204] wl1_dn[203]
+ wl1_dn[202] wl1_dn[201] wl1_dn[200] wl1_dn[199] wl1_dn[198] wl1_dn[197] wl1_dn[196]
+ wl1_dn[195] wl1_dn[194] wl1_dn[193] wl1_dn[192] wl1_dn[191] wl1_dn[190] wl1_dn[189]
+ wl1_dn[188] wl1_dn[187] wl1_dn[186] wl1_dn[185] wl1_dn[184] wl1_dn[183] wl1_dn[182]
+ wl1_dn[181] wl1_dn[180] wl1_dn[179] wl1_dn[178] wl1_dn[177] wl1_dn[176] wl1_dn[175]
+ wl1_dn[174] wl1_dn[173] wl1_dn[172] wl1_dn[171] wl1_dn[170] wl1_dn[169] wl1_dn[168]
+ wl1_dn[167] wl1_dn[166] wl1_dn[165] wl1_dn[164] wl1_dn[163] wl1_dn[162] wl1_dn[161]
+ wl1_dn[160] wl1_dn[159] wl1_dn[158] wl1_dn[157] wl1_dn[156] wl1_dn[155] wl1_dn[154]
+ wl1_dn[153] wl1_dn[152] wl1_dn[151] wl1_dn[150] wl1_dn[149] wl1_dn[148] wl1_dn[147]
+ wl1_dn[146] wl1_dn[145] wl1_dn[144] wl1_dn[143] wl1_dn[142] wl1_dn[141] wl1_dn[140]
+ wl1_dn[139] wl1_dn[138] wl1_dn[137] wl1_dn[136] wl1_dn[135] wl1_dn[134] wl1_dn[133]
+ wl1_dn[132] wl1_dn[131] wl1_dn[130] wl1_dn[129] wl1_dn[128] wl1_dn[127] wl1_dn[126]
+ wl1_dn[125] wl1_dn[124] wl1_dn[123] wl1_dn[122] wl1_dn[121] wl1_dn[120] wl1_dn[119]
+ wl1_dn[118] wl1_dn[117] wl1_dn[116] wl1_dn[115] wl1_dn[114] wl1_dn[113] wl1_dn[112]
+ wl1_dn[111] wl1_dn[110] wl1_dn[109] wl1_dn[108] wl1_dn[107] wl1_dn[106] wl1_dn[105]
+ wl1_dn[104] wl1_dn[103] wl1_dn[102] wl1_dn[101] wl1_dn[100] wl1_dn[99] wl1_dn[98]
+ wl1_dn[97] wl1_dn[96] wl1_dn[95] wl1_dn[94] wl1_dn[93] wl1_dn[92] wl1_dn[91] wl1_dn[90]
+ wl1_dn[89] wl1_dn[88] wl1_dn[87] wl1_dn[86] wl1_dn[85] wl1_dn[84] wl1_dn[83] wl1_dn[82]
+ wl1_dn[81] wl1_dn[80] wl1_dn[79] wl1_dn[78] wl1_dn[77] wl1_dn[76] wl1_dn[75] wl1_dn[74]
+ wl1_dn[73] wl1_dn[72] wl1_dn[71] wl1_dn[70] wl1_dn[69] wl1_dn[68] wl1_dn[67] wl1_dn[66]
+ wl1_dn[65] wl1_dn[64] wl1_dn[63] wl1_dn[62] wl1_dn[61] wl1_dn[60] wl1_dn[59] wl1_dn[58]
+ wl1_dn[57] wl1_dn[56] wl1_dn[55] wl1_dn[54] wl1_dn[53] wl1_dn[52] wl1_dn[51] wl1_dn[50]
+ wl1_dn[49] wl1_dn[48] wl1_dn[47] wl1_dn[46] wl1_dn[45] wl1_dn[44] wl1_dn[43] wl1_dn[42]
+ wl1_dn[41] wl1_dn[40] wl1_dn[39] wl1_dn[38] wl1_dn[37] wl1_dn[36] wl1_dn[35] wl1_dn[34]
+ wl1_dn[33] wl1_dn[32] wl1_dn[31] wl1_dn[30] wl1_dn[29] wl1_dn[28] wl1_dn[27] wl1_dn[26]
+ wl1_dn[25] wl1_dn[24] wl1_dn[23] wl1_dn[22] wl1_dn[21] wl1_dn[20] wl1_dn[19] wl1_dn[18]
+ wl1_dn[17] wl1_dn[16] wl1_dn[15] wl1_dn[14] wl1_dn[13] wl1_dn[12] wl1_dn[11] wl1_dn[10]
+ wl1_dn[9] wl1_dn[8] wl1_dn[7] wl1_dn[6] wl1_dn[5] wl1_dn[4] wl1_dn[3] wl1_dn[2]
+ wl1_dn[1] wl1_dn[0] wl1_up[255] wl1_up[254] wl1_up[253] wl1_up[252] wl1_up[251]
+ wl1_up[250] wl1_up[249] wl1_up[248] wl1_up[247] wl1_up[246] wl1_up[245] wl1_up[244]
+ wl1_up[243] wl1_up[242] wl1_up[241] wl1_up[240] wl1_up[239] wl1_up[238] wl1_up[237]
+ wl1_up[236] wl1_up[235] wl1_up[234] wl1_up[233] wl1_up[232] wl1_up[231] wl1_up[230]
+ wl1_up[229] wl1_up[228] wl1_up[227] wl1_up[226] wl1_up[225] wl1_up[224] wl1_up[223]
+ wl1_up[222] wl1_up[221] wl1_up[220] wl1_up[219] wl1_up[218] wl1_up[217] wl1_up[216]
+ wl1_up[215] wl1_up[214] wl1_up[213] wl1_up[212] wl1_up[211] wl1_up[210] wl1_up[209]
+ wl1_up[208] wl1_up[207] wl1_up[206] wl1_up[205] wl1_up[204] wl1_up[203] wl1_up[202]
+ wl1_up[201] wl1_up[200] wl1_up[199] wl1_up[198] wl1_up[197] wl1_up[196] wl1_up[195]
+ wl1_up[194] wl1_up[193] wl1_up[192] wl1_up[191] wl1_up[190] wl1_up[189] wl1_up[188]
+ wl1_up[187] wl1_up[186] wl1_up[185] wl1_up[184] wl1_up[183] wl1_up[182] wl1_up[181]
+ wl1_up[180] wl1_up[179] wl1_up[178] wl1_up[177] wl1_up[176] wl1_up[175] wl1_up[174]
+ wl1_up[173] wl1_up[172] wl1_up[171] wl1_up[170] wl1_up[169] wl1_up[168] wl1_up[167]
+ wl1_up[166] wl1_up[165] wl1_up[164] wl1_up[163] wl1_up[162] wl1_up[161] wl1_up[160]
+ wl1_up[159] wl1_up[158] wl1_up[157] wl1_up[156] wl1_up[155] wl1_up[154] wl1_up[153]
+ wl1_up[152] wl1_up[151] wl1_up[150] wl1_up[149] wl1_up[148] wl1_up[147] wl1_up[146]
+ wl1_up[145] wl1_up[144] wl1_up[143] wl1_up[142] wl1_up[141] wl1_up[140] wl1_up[139]
+ wl1_up[138] wl1_up[137] wl1_up[136] wl1_up[135] wl1_up[134] wl1_up[133] wl1_up[132]
+ wl1_up[131] wl1_up[130] wl1_up[129] wl1_up[128] wl1_up[127] wl1_up[126] wl1_up[125]
+ wl1_up[124] wl1_up[123] wl1_up[122] wl1_up[121] wl1_up[120] wl1_up[119] wl1_up[118]
+ wl1_up[117] wl1_up[116] wl1_up[115] wl1_up[114] wl1_up[113] wl1_up[112] wl1_up[111]
+ wl1_up[110] wl1_up[109] wl1_up[108] wl1_up[107] wl1_up[106] wl1_up[105] wl1_up[104]
+ wl1_up[103] wl1_up[102] wl1_up[101] wl1_up[100] wl1_up[99] wl1_up[98] wl1_up[97]
+ wl1_up[96] wl1_up[95] wl1_up[94] wl1_up[93] wl1_up[92] wl1_up[91] wl1_up[90] wl1_up[89]
+ wl1_up[88] wl1_up[87] wl1_up[86] wl1_up[85] wl1_up[84] wl1_up[83] wl1_up[82] wl1_up[81]
+ wl1_up[80] wl1_up[79] wl1_up[78] wl1_up[77] wl1_up[76] wl1_up[75] wl1_up[74] wl1_up[73]
+ wl1_up[72] wl1_up[71] wl1_up[70] wl1_up[69] wl1_up[68] wl1_up[67] wl1_up[66] wl1_up[65]
+ wl1_up[64] wl1_up[63] wl1_up[62] wl1_up[61] wl1_up[60] wl1_up[59] wl1_up[58] wl1_up[57]
+ wl1_up[56] wl1_up[55] wl1_up[54] wl1_up[53] wl1_up[52] wl1_up[51] wl1_up[50] wl1_up[49]
+ wl1_up[48] wl1_up[47] wl1_up[46] wl1_up[45] wl1_up[44] wl1_up[43] wl1_up[42] wl1_up[41]
+ wl1_up[40] wl1_up[39] wl1_up[38] wl1_up[37] wl1_up[36] wl1_up[35] wl1_up[34] wl1_up[33]
+ wl1_up[32] wl1_up[31] wl1_up[30] wl1_up[29] wl1_up[28] wl1_up[27] wl1_up[26] wl1_up[25]
+ wl1_up[24] wl1_up[23] wl1_up[22] wl1_up[21] wl1_up[20] wl1_up[19] wl1_up[18] wl1_up[17]
+ wl1_up[16] wl1_up[15] wl1_up[14] wl1_up[13] wl1_up[12] wl1_up[11] wl1_up[10] wl1_up[9]
+ wl1_up[8] wl1_up[7] wl1_up[6] wl1_up[5] wl1_up[4] wl1_up[3] wl1_up[2] wl1_up[1]
+ wl1_up[0] wrclk_dn wrclk_up wrcolsel0_dn[3] wrcolsel0_dn[2] wrcolsel0_dn[1] wrcolsel0_dn[0]
+ wrcolsel0_up[3] wrcolsel0_up[2] wrcolsel0_up[1] wrcolsel0_up[0] wrcolsel1_dn[3]
+ wrcolsel1_dn[2] wrcolsel1_dn[1] wrcolsel1_dn[0] wrcolsel1_up[3] wrcolsel1_up[2]
+ wrcolsel1_up[1] wrcolsel1_up[0] wrdataen_dn wrdataen_up wrwl wrwlclkmx wrwlpw[1]
+ wrwlpw[0] ip78d6hcf2sr4096x135m4i2k4w8r2lya_cntrl
Xitrkfullslc clkwrsynckicknn finekick[3] finekick[2] finekick[1] finekick[0] fz_synckick
+ fz_syncrd fz_syncwr nblkick rdwl rdwlclkmx rdwlpw[3] rdwlpw[2] rdwlpw[1] rdwlpw[0]
+ redwl0_up[1] redwl0_up[0] redwl1_up[1] redwl1_up[0] trkwllvlnn[2] trkwllvlnn[1]
+ trkwllvlnn[0] vcc vss wl0_up[255] wl0_up[254] wl0_up[253] wl0_up[252] wl0_up[251]
+ wl0_up[250] wl0_up[249] wl0_up[248] wl0_up[247] wl0_up[246] wl0_up[245] wl0_up[244]
+ wl0_up[243] wl0_up[242] wl0_up[241] wl0_up[240] wl0_up[239] wl0_up[238] wl0_up[237]
+ wl0_up[236] wl0_up[235] wl0_up[234] wl0_up[233] wl0_up[232] wl0_up[231] wl0_up[230]
+ wl0_up[229] wl0_up[228] wl0_up[227] wl0_up[226] wl0_up[225] wl0_up[224] wl0_up[223]
+ wl0_up[222] wl0_up[221] wl0_up[220] wl0_up[219] wl0_up[218] wl0_up[217] wl0_up[216]
+ wl0_up[215] wl0_up[214] wl0_up[213] wl0_up[212] wl0_up[211] wl0_up[210] wl0_up[209]
+ wl0_up[208] wl0_up[207] wl0_up[206] wl0_up[205] wl0_up[204] wl0_up[203] wl0_up[202]
+ wl0_up[201] wl0_up[200] wl0_up[199] wl0_up[198] wl0_up[197] wl0_up[196] wl0_up[195]
+ wl0_up[194] wl0_up[193] wl0_up[192] wl0_up[191] wl0_up[190] wl0_up[189] wl0_up[188]
+ wl0_up[187] wl0_up[186] wl0_up[185] wl0_up[184] wl0_up[183] wl0_up[182] wl0_up[181]
+ wl0_up[180] wl0_up[179] wl0_up[178] wl0_up[177] wl0_up[176] wl0_up[175] wl0_up[174]
+ wl0_up[173] wl0_up[172] wl0_up[171] wl0_up[170] wl0_up[169] wl0_up[168] wl0_up[167]
+ wl0_up[166] wl0_up[165] wl0_up[164] wl0_up[163] wl0_up[162] wl0_up[161] wl0_up[160]
+ wl0_up[159] wl0_up[158] wl0_up[157] wl0_up[156] wl0_up[155] wl0_up[154] wl0_up[153]
+ wl0_up[152] wl0_up[151] wl0_up[150] wl0_up[149] wl0_up[148] wl0_up[147] wl0_up[146]
+ wl0_up[145] wl0_up[144] wl0_up[143] wl0_up[142] wl0_up[141] wl0_up[140] wl0_up[139]
+ wl0_up[138] wl0_up[137] wl0_up[136] wl0_up[135] wl0_up[134] wl0_up[133] wl0_up[132]
+ wl0_up[131] wl0_up[130] wl0_up[129] wl0_up[128] wl0_up[127] wl0_up[126] wl0_up[125]
+ wl0_up[124] wl0_up[123] wl0_up[122] wl0_up[121] wl0_up[120] wl0_up[119] wl0_up[118]
+ wl0_up[117] wl0_up[116] wl0_up[115] wl0_up[114] wl0_up[113] wl0_up[112] wl0_up[111]
+ wl0_up[110] wl0_up[109] wl0_up[108] wl0_up[107] wl0_up[106] wl0_up[105] wl0_up[104]
+ wl0_up[103] wl0_up[102] wl0_up[101] wl0_up[100] wl0_up[99] wl0_up[98] wl0_up[97]
+ wl0_up[96] wl0_up[95] wl0_up[94] wl0_up[93] wl0_up[92] wl0_up[91] wl0_up[90] wl0_up[89]
+ wl0_up[88] wl0_up[87] wl0_up[86] wl0_up[85] wl0_up[84] wl0_up[83] wl0_up[82] wl0_up[81]
+ wl0_up[80] wl0_up[79] wl0_up[78] wl0_up[77] wl0_up[76] wl0_up[75] wl0_up[74] wl0_up[73]
+ wl0_up[72] wl0_up[71] wl0_up[70] wl0_up[69] wl0_up[68] wl0_up[67] wl0_up[66] wl0_up[65]
+ wl0_up[64] wl0_up[63] wl0_up[62] wl0_up[61] wl0_up[60] wl0_up[59] wl0_up[58] wl0_up[57]
+ wl0_up[56] wl0_up[55] wl0_up[54] wl0_up[53] wl0_up[52] wl0_up[51] wl0_up[50] wl0_up[49]
+ wl0_up[48] wl0_up[47] wl0_up[46] wl0_up[45] wl0_up[44] wl0_up[43] wl0_up[42] wl0_up[41]
+ wl0_up[40] wl0_up[39] wl0_up[38] wl0_up[37] wl0_up[36] wl0_up[35] wl0_up[34] wl0_up[33]
+ wl0_up[32] wl0_up[31] wl0_up[30] wl0_up[29] wl0_up[28] wl0_up[27] wl0_up[26] wl0_up[25]
+ wl0_up[24] wl0_up[23] wl0_up[22] wl0_up[21] wl0_up[20] wl0_up[19] wl0_up[18] wl0_up[17]
+ wl0_up[16] wl0_up[15] wl0_up[14] wl0_up[13] wl0_up[12] wl0_up[11] wl0_up[10] wl0_up[9]
+ wl0_up[8] wl0_up[7] wl0_up[6] wl0_up[5] wl0_up[4] wl0_up[3] wl0_up[2] wl0_up[1]
+ wl0_up[0] wl1_up[255] wl1_up[254] wl1_up[253] wl1_up[252] wl1_up[251] wl1_up[250]
+ wl1_up[249] wl1_up[248] wl1_up[247] wl1_up[246] wl1_up[245] wl1_up[244] wl1_up[243]
+ wl1_up[242] wl1_up[241] wl1_up[240] wl1_up[239] wl1_up[238] wl1_up[237] wl1_up[236]
+ wl1_up[235] wl1_up[234] wl1_up[233] wl1_up[232] wl1_up[231] wl1_up[230] wl1_up[229]
+ wl1_up[228] wl1_up[227] wl1_up[226] wl1_up[225] wl1_up[224] wl1_up[223] wl1_up[222]
+ wl1_up[221] wl1_up[220] wl1_up[219] wl1_up[218] wl1_up[217] wl1_up[216] wl1_up[215]
+ wl1_up[214] wl1_up[213] wl1_up[212] wl1_up[211] wl1_up[210] wl1_up[209] wl1_up[208]
+ wl1_up[207] wl1_up[206] wl1_up[205] wl1_up[204] wl1_up[203] wl1_up[202] wl1_up[201]
+ wl1_up[200] wl1_up[199] wl1_up[198] wl1_up[197] wl1_up[196] wl1_up[195] wl1_up[194]
+ wl1_up[193] wl1_up[192] wl1_up[191] wl1_up[190] wl1_up[189] wl1_up[188] wl1_up[187]
+ wl1_up[186] wl1_up[185] wl1_up[184] wl1_up[183] wl1_up[182] wl1_up[181] wl1_up[180]
+ wl1_up[179] wl1_up[178] wl1_up[177] wl1_up[176] wl1_up[175] wl1_up[174] wl1_up[173]
+ wl1_up[172] wl1_up[171] wl1_up[170] wl1_up[169] wl1_up[168] wl1_up[167] wl1_up[166]
+ wl1_up[165] wl1_up[164] wl1_up[163] wl1_up[162] wl1_up[161] wl1_up[160] wl1_up[159]
+ wl1_up[158] wl1_up[157] wl1_up[156] wl1_up[155] wl1_up[154] wl1_up[153] wl1_up[152]
+ wl1_up[151] wl1_up[150] wl1_up[149] wl1_up[148] wl1_up[147] wl1_up[146] wl1_up[145]
+ wl1_up[144] wl1_up[143] wl1_up[142] wl1_up[141] wl1_up[140] wl1_up[139] wl1_up[138]
+ wl1_up[137] wl1_up[136] wl1_up[135] wl1_up[134] wl1_up[133] wl1_up[132] wl1_up[131]
+ wl1_up[130] wl1_up[129] wl1_up[128] wl1_up[127] wl1_up[126] wl1_up[125] wl1_up[124]
+ wl1_up[123] wl1_up[122] wl1_up[121] wl1_up[120] wl1_up[119] wl1_up[118] wl1_up[117]
+ wl1_up[116] wl1_up[115] wl1_up[114] wl1_up[113] wl1_up[112] wl1_up[111] wl1_up[110]
+ wl1_up[109] wl1_up[108] wl1_up[107] wl1_up[106] wl1_up[105] wl1_up[104] wl1_up[103]
+ wl1_up[102] wl1_up[101] wl1_up[100] wl1_up[99] wl1_up[98] wl1_up[97] wl1_up[96]
+ wl1_up[95] wl1_up[94] wl1_up[93] wl1_up[92] wl1_up[91] wl1_up[90] wl1_up[89] wl1_up[88]
+ wl1_up[87] wl1_up[86] wl1_up[85] wl1_up[84] wl1_up[83] wl1_up[82] wl1_up[81] wl1_up[80]
+ wl1_up[79] wl1_up[78] wl1_up[77] wl1_up[76] wl1_up[75] wl1_up[74] wl1_up[73] wl1_up[72]
+ wl1_up[71] wl1_up[70] wl1_up[69] wl1_up[68] wl1_up[67] wl1_up[66] wl1_up[65] wl1_up[64]
+ wl1_up[63] wl1_up[62] wl1_up[61] wl1_up[60] wl1_up[59] wl1_up[58] wl1_up[57] wl1_up[56]
+ wl1_up[55] wl1_up[54] wl1_up[53] wl1_up[52] wl1_up[51] wl1_up[50] wl1_up[49] wl1_up[48]
+ wl1_up[47] wl1_up[46] wl1_up[45] wl1_up[44] wl1_up[43] wl1_up[42] wl1_up[41] wl1_up[40]
+ wl1_up[39] wl1_up[38] wl1_up[37] wl1_up[36] wl1_up[35] wl1_up[34] wl1_up[33] wl1_up[32]
+ wl1_up[31] wl1_up[30] wl1_up[29] wl1_up[28] wl1_up[27] wl1_up[26] wl1_up[25] wl1_up[24]
+ wl1_up[23] wl1_up[22] wl1_up[21] wl1_up[20] wl1_up[19] wl1_up[18] wl1_up[17] wl1_up[16]
+ wl1_up[15] wl1_up[14] wl1_up[13] wl1_up[12] wl1_up[11] wl1_up[10] wl1_up[9] wl1_up[8]
+ wl1_up[7] wl1_up[6] wl1_up[5] wl1_up[4] wl1_up[3] wl1_up[2] wl1_up[1] wl1_up[0]
+ wrwl wrwlclkmx wrwlpw[1] wrwlpw[0] ip78d6hcf2sr4096x135m4i2k4w8r2lya_trkfullslc
Xsrambank[1] idin1l[134] idin1l[133] idin1l[132] idin1l[131] idin1l[130] idin1l[129]
+ idin1l[128] idin1l[127] idin1l[126] idin1l[125] idin1l[124] idin1l[123] idin1l[122]
+ idin1l[121] idin1l[120] idin1l[119] idin1l[118] idin1l[117] idin1l[116] idin1l[115]
+ idin1l[114] idin1l[113] idin1l[112] idin1l[111] idin1l[110] idin1l[109] idin1l[108]
+ idin1l[107] idin1l[106] idin1l[105] idin1l[104] idin1l[103] idin1l[102] idin1l[101]
+ idin1l[100] idin1l[99] idin1l[98] idin1l[97] idin1l[96] idin1l[95] idin1l[94]
+ idin1l[93] idin1l[92] idin1l[91] idin1l[90] idin1l[89] idin1l[88] idin1l[87] idin1l[86]
+ idin1l[85] idin1l[84] idin1l[83] idin1l[82] idin1l[81] idin1l[80] idin1l[79] idin1l[78]
+ idin1l[77] idin1l[76] idin1l[75] idin1l[74] idin1l[73] idin1l[72] idin1l[71] idin1l[70]
+ idin1l[69] idin1l[68] lyaennn lyal0bl[134] lyal0bl[133] lyal0bl[132] lyal0bl[131]
+ lyal0bl[130] lyal0bl[129] lyal0bl[128] lyal0bl[127] lyal0bl[126] lyal0bl[125]
+ lyal0bl[124] lyal0bl[123] lyal0bl[122] lyal0bl[121] lyal0bl[120] lyal0bl[119]
+ lyal0bl[118] lyal0bl[117] lyal0bl[116] lyal0bl[115] lyal0bl[114] lyal0bl[113]
+ lyal0bl[112] lyal0bl[111] lyal0bl[110] lyal0bl[109] lyal0bl[108] lyal0bl[107]
+ lyal0bl[106] lyal0bl[105] lyal0bl[104] lyal0bl[103] lyal0bl[102] lyal0bl[101]
+ lyal0bl[100] lyal0bl[99] lyal0bl[98] lyal0bl[97] lyal0bl[96] lyal0bl[95] lyal0bl[94]
+ lyal0bl[93] lyal0bl[92] lyal0bl[91] lyal0bl[90] lyal0bl[89] lyal0bl[88] lyal0bl[87]
+ lyal0bl[86] lyal0bl[85] lyal0bl[84] lyal0bl[83] lyal0bl[82] lyal0bl[81] lyal0bl[80]
+ lyal0bl[79] lyal0bl[78] lyal0bl[77] lyal0bl[76] lyal0bl[75] lyal0bl[74] lyal0bl[73]
+ lyal0bl[72] lyal0bl[71] lyal0bl[70] lyal0bl[69] lyal0bl[68] lyal0blnn[134] lyal0blnn[133]
+ lyal0blnn[132] lyal0blnn[131] lyal0blnn[130] lyal0blnn[129] lyal0blnn[128] lyal0blnn[127]
+ lyal0blnn[126] lyal0blnn[125] lyal0blnn[124] lyal0blnn[123] lyal0blnn[122] lyal0blnn[121]
+ lyal0blnn[120] lyal0blnn[119] lyal0blnn[118] lyal0blnn[117] lyal0blnn[116] lyal0blnn[115]
+ lyal0blnn[114] lyal0blnn[113] lyal0blnn[112] lyal0blnn[111] lyal0blnn[110] lyal0blnn[109]
+ lyal0blnn[108] lyal0blnn[107] lyal0blnn[106] lyal0blnn[105] lyal0blnn[104] lyal0blnn[103]
+ lyal0blnn[102] lyal0blnn[101] lyal0blnn[100] lyal0blnn[99] lyal0blnn[98] lyal0blnn[97]
+ lyal0blnn[96] lyal0blnn[95] lyal0blnn[94] lyal0blnn[93] lyal0blnn[92] lyal0blnn[91]
+ lyal0blnn[90] lyal0blnn[89] lyal0blnn[88] lyal0blnn[87] lyal0blnn[86] lyal0blnn[85]
+ lyal0blnn[84] lyal0blnn[83] lyal0blnn[82] lyal0blnn[81] lyal0blnn[80] lyal0blnn[79]
+ lyal0blnn[78] lyal0blnn[77] lyal0blnn[76] lyal0blnn[75] lyal0blnn[74] lyal0blnn[73]
+ lyal0blnn[72] lyal0blnn[71] lyal0blnn[70] lyal0blnn[69] lyal0blnn[68] nbl_kicknn_up
+ pcnn0_up pcnn1_up rddataout[134] rddataout[133] rddataout[132] rddataout[131]
+ rddataout[130] rddataout[129] rddataout[128] rddataout[127] rddataout[126] rddataout[125]
+ rddataout[124] rddataout[123] rddataout[122] rddataout[121] rddataout[120] rddataout[119]
+ rddataout[118] rddataout[117] rddataout[116] rddataout[115] rddataout[114] rddataout[113]
+ rddataout[112] rddataout[111] rddataout[110] rddataout[109] rddataout[108] rddataout[107]
+ rddataout[106] rddataout[105] rddataout[104] rddataout[103] rddataout[102] rddataout[101]
+ rddataout[100] rddataout[99] rddataout[98] rddataout[97] rddataout[96] rddataout[95]
+ rddataout[94] rddataout[93] rddataout[92] rddataout[91] rddataout[90] rddataout[89]
+ rddataout[88] rddataout[87] rddataout[86] rddataout[85] rddataout[84] rddataout[83]
+ rddataout[82] rddataout[81] rddataout[80] rddataout[79] rddataout[78] rddataout[77]
+ rddataout[76] rddataout[75] rddataout[74] rddataout[73] rddataout[72] rddataout[71]
+ rddataout[70] rddataout[69] rddataout[68] rdysel0_up[3] rdysel0_up[2] rdysel0_up[1]
+ rdysel0_up[0] rdysel1_up[3] rdysel1_up[2] rdysel1_up[1] rdysel1_up[0] redwl0_up[1]
+ redwl0_up[0] redwl1_up[1] redwl1_up[0] saenn_up sapchnn_up vcc vss waenn_up[2]
+ waenn_up[1] waenn_up[0] wl0_up[255] wl0_up[254] wl0_up[253] wl0_up[252] wl0_up[251]
+ wl0_up[250] wl0_up[249] wl0_up[248] wl0_up[247] wl0_up[246] wl0_up[245] wl0_up[244]
+ wl0_up[243] wl0_up[242] wl0_up[241] wl0_up[240] wl0_up[239] wl0_up[238] wl0_up[237]
+ wl0_up[236] wl0_up[235] wl0_up[234] wl0_up[233] wl0_up[232] wl0_up[231] wl0_up[230]
+ wl0_up[229] wl0_up[228] wl0_up[227] wl0_up[226] wl0_up[225] wl0_up[224] wl0_up[223]
+ wl0_up[222] wl0_up[221] wl0_up[220] wl0_up[219] wl0_up[218] wl0_up[217] wl0_up[216]
+ wl0_up[215] wl0_up[214] wl0_up[213] wl0_up[212] wl0_up[211] wl0_up[210] wl0_up[209]
+ wl0_up[208] wl0_up[207] wl0_up[206] wl0_up[205] wl0_up[204] wl0_up[203] wl0_up[202]
+ wl0_up[201] wl0_up[200] wl0_up[199] wl0_up[198] wl0_up[197] wl0_up[196] wl0_up[195]
+ wl0_up[194] wl0_up[193] wl0_up[192] wl0_up[191] wl0_up[190] wl0_up[189] wl0_up[188]
+ wl0_up[187] wl0_up[186] wl0_up[185] wl0_up[184] wl0_up[183] wl0_up[182] wl0_up[181]
+ wl0_up[180] wl0_up[179] wl0_up[178] wl0_up[177] wl0_up[176] wl0_up[175] wl0_up[174]
+ wl0_up[173] wl0_up[172] wl0_up[171] wl0_up[170] wl0_up[169] wl0_up[168] wl0_up[167]
+ wl0_up[166] wl0_up[165] wl0_up[164] wl0_up[163] wl0_up[162] wl0_up[161] wl0_up[160]
+ wl0_up[159] wl0_up[158] wl0_up[157] wl0_up[156] wl0_up[155] wl0_up[154] wl0_up[153]
+ wl0_up[152] wl0_up[151] wl0_up[150] wl0_up[149] wl0_up[148] wl0_up[147] wl0_up[146]
+ wl0_up[145] wl0_up[144] wl0_up[143] wl0_up[142] wl0_up[141] wl0_up[140] wl0_up[139]
+ wl0_up[138] wl0_up[137] wl0_up[136] wl0_up[135] wl0_up[134] wl0_up[133] wl0_up[132]
+ wl0_up[131] wl0_up[130] wl0_up[129] wl0_up[128] wl0_up[127] wl0_up[126] wl0_up[125]
+ wl0_up[124] wl0_up[123] wl0_up[122] wl0_up[121] wl0_up[120] wl0_up[119] wl0_up[118]
+ wl0_up[117] wl0_up[116] wl0_up[115] wl0_up[114] wl0_up[113] wl0_up[112] wl0_up[111]
+ wl0_up[110] wl0_up[109] wl0_up[108] wl0_up[107] wl0_up[106] wl0_up[105] wl0_up[104]
+ wl0_up[103] wl0_up[102] wl0_up[101] wl0_up[100] wl0_up[99] wl0_up[98] wl0_up[97]
+ wl0_up[96] wl0_up[95] wl0_up[94] wl0_up[93] wl0_up[92] wl0_up[91] wl0_up[90] wl0_up[89]
+ wl0_up[88] wl0_up[87] wl0_up[86] wl0_up[85] wl0_up[84] wl0_up[83] wl0_up[82] wl0_up[81]
+ wl0_up[80] wl0_up[79] wl0_up[78] wl0_up[77] wl0_up[76] wl0_up[75] wl0_up[74] wl0_up[73]
+ wl0_up[72] wl0_up[71] wl0_up[70] wl0_up[69] wl0_up[68] wl0_up[67] wl0_up[66] wl0_up[65]
+ wl0_up[64] wl0_up[63] wl0_up[62] wl0_up[61] wl0_up[60] wl0_up[59] wl0_up[58] wl0_up[57]
+ wl0_up[56] wl0_up[55] wl0_up[54] wl0_up[53] wl0_up[52] wl0_up[51] wl0_up[50] wl0_up[49]
+ wl0_up[48] wl0_up[47] wl0_up[46] wl0_up[45] wl0_up[44] wl0_up[43] wl0_up[42] wl0_up[41]
+ wl0_up[40] wl0_up[39] wl0_up[38] wl0_up[37] wl0_up[36] wl0_up[35] wl0_up[34] wl0_up[33]
+ wl0_up[32] wl0_up[31] wl0_up[30] wl0_up[29] wl0_up[28] wl0_up[27] wl0_up[26] wl0_up[25]
+ wl0_up[24] wl0_up[23] wl0_up[22] wl0_up[21] wl0_up[20] wl0_up[19] wl0_up[18] wl0_up[17]
+ wl0_up[16] wl0_up[15] wl0_up[14] wl0_up[13] wl0_up[12] wl0_up[11] wl0_up[10] wl0_up[9]
+ wl0_up[8] wl0_up[7] wl0_up[6] wl0_up[5] wl0_up[4] wl0_up[3] wl0_up[2] wl0_up[1]
+ wl0_up[0] wl1_up[255] wl1_up[254] wl1_up[253] wl1_up[252] wl1_up[251] wl1_up[250]
+ wl1_up[249] wl1_up[248] wl1_up[247] wl1_up[246] wl1_up[245] wl1_up[244] wl1_up[243]
+ wl1_up[242] wl1_up[241] wl1_up[240] wl1_up[239] wl1_up[238] wl1_up[237] wl1_up[236]
+ wl1_up[235] wl1_up[234] wl1_up[233] wl1_up[232] wl1_up[231] wl1_up[230] wl1_up[229]
+ wl1_up[228] wl1_up[227] wl1_up[226] wl1_up[225] wl1_up[224] wl1_up[223] wl1_up[222]
+ wl1_up[221] wl1_up[220] wl1_up[219] wl1_up[218] wl1_up[217] wl1_up[216] wl1_up[215]
+ wl1_up[214] wl1_up[213] wl1_up[212] wl1_up[211] wl1_up[210] wl1_up[209] wl1_up[208]
+ wl1_up[207] wl1_up[206] wl1_up[205] wl1_up[204] wl1_up[203] wl1_up[202] wl1_up[201]
+ wl1_up[200] wl1_up[199] wl1_up[198] wl1_up[197] wl1_up[196] wl1_up[195] wl1_up[194]
+ wl1_up[193] wl1_up[192] wl1_up[191] wl1_up[190] wl1_up[189] wl1_up[188] wl1_up[187]
+ wl1_up[186] wl1_up[185] wl1_up[184] wl1_up[183] wl1_up[182] wl1_up[181] wl1_up[180]
+ wl1_up[179] wl1_up[178] wl1_up[177] wl1_up[176] wl1_up[175] wl1_up[174] wl1_up[173]
+ wl1_up[172] wl1_up[171] wl1_up[170] wl1_up[169] wl1_up[168] wl1_up[167] wl1_up[166]
+ wl1_up[165] wl1_up[164] wl1_up[163] wl1_up[162] wl1_up[161] wl1_up[160] wl1_up[159]
+ wl1_up[158] wl1_up[157] wl1_up[156] wl1_up[155] wl1_up[154] wl1_up[153] wl1_up[152]
+ wl1_up[151] wl1_up[150] wl1_up[149] wl1_up[148] wl1_up[147] wl1_up[146] wl1_up[145]
+ wl1_up[144] wl1_up[143] wl1_up[142] wl1_up[141] wl1_up[140] wl1_up[139] wl1_up[138]
+ wl1_up[137] wl1_up[136] wl1_up[135] wl1_up[134] wl1_up[133] wl1_up[132] wl1_up[131]
+ wl1_up[130] wl1_up[129] wl1_up[128] wl1_up[127] wl1_up[126] wl1_up[125] wl1_up[124]
+ wl1_up[123] wl1_up[122] wl1_up[121] wl1_up[120] wl1_up[119] wl1_up[118] wl1_up[117]
+ wl1_up[116] wl1_up[115] wl1_up[114] wl1_up[113] wl1_up[112] wl1_up[111] wl1_up[110]
+ wl1_up[109] wl1_up[108] wl1_up[107] wl1_up[106] wl1_up[105] wl1_up[104] wl1_up[103]
+ wl1_up[102] wl1_up[101] wl1_up[100] wl1_up[99] wl1_up[98] wl1_up[97] wl1_up[96]
+ wl1_up[95] wl1_up[94] wl1_up[93] wl1_up[92] wl1_up[91] wl1_up[90] wl1_up[89] wl1_up[88]
+ wl1_up[87] wl1_up[86] wl1_up[85] wl1_up[84] wl1_up[83] wl1_up[82] wl1_up[81] wl1_up[80]
+ wl1_up[79] wl1_up[78] wl1_up[77] wl1_up[76] wl1_up[75] wl1_up[74] wl1_up[73] wl1_up[72]
+ wl1_up[71] wl1_up[70] wl1_up[69] wl1_up[68] wl1_up[67] wl1_up[66] wl1_up[65] wl1_up[64]
+ wl1_up[63] wl1_up[62] wl1_up[61] wl1_up[60] wl1_up[59] wl1_up[58] wl1_up[57] wl1_up[56]
+ wl1_up[55] wl1_up[54] wl1_up[53] wl1_up[52] wl1_up[51] wl1_up[50] wl1_up[49] wl1_up[48]
+ wl1_up[47] wl1_up[46] wl1_up[45] wl1_up[44] wl1_up[43] wl1_up[42] wl1_up[41] wl1_up[40]
+ wl1_up[39] wl1_up[38] wl1_up[37] wl1_up[36] wl1_up[35] wl1_up[34] wl1_up[33] wl1_up[32]
+ wl1_up[31] wl1_up[30] wl1_up[29] wl1_up[28] wl1_up[27] wl1_up[26] wl1_up[25] wl1_up[24]
+ wl1_up[23] wl1_up[22] wl1_up[21] wl1_up[20] wl1_up[19] wl1_up[18] wl1_up[17] wl1_up[16]
+ wl1_up[15] wl1_up[14] wl1_up[13] wl1_up[12] wl1_up[11] wl1_up[10] wl1_up[9] wl1_up[8]
+ wl1_up[7] wl1_up[6] wl1_up[5] wl1_up[4] wl1_up[3] wl1_up[2] wl1_up[1] wl1_up[0]
+ wrclk_up wrcolsel0_up[3] wrcolsel0_up[2] wrcolsel0_up[1] wrcolsel0_up[0] wrcolsel1_up[3]
+ wrcolsel1_up[2] wrcolsel1_up[1] wrcolsel1_up[0] wrdataen_up ip78d6hcf2sr4096x135m4i2k4w8r2lya_bank_up
Xsrambank[0] idin1l[67] idin1l[66] idin1l[65] idin1l[64] idin1l[63] idin1l[62] idin1l[61]
+ idin1l[60] idin1l[59] idin1l[58] idin1l[57] idin1l[56] idin1l[55] idin1l[54] idin1l[53]
+ idin1l[52] idin1l[51] idin1l[50] idin1l[49] idin1l[48] idin1l[47] idin1l[46] idin1l[45]
+ idin1l[44] idin1l[43] idin1l[42] idin1l[41] idin1l[40] idin1l[39] idin1l[38] idin1l[37]
+ idin1l[36] idin1l[35] idin1l[34] idin1l[33] idin1l[32] idin1l[31] idin1l[30] idin1l[29]
+ idin1l[28] idin1l[27] idin1l[26] idin1l[25] idin1l[24] idin1l[23] idin1l[22] idin1l[21]
+ idin1l[20] idin1l[19] idin1l[18] idin1l[17] idin1l[16] idin1l[15] idin1l[14] idin1l[13]
+ idin1l[12] idin1l[11] idin1l[10] idin1l[9] idin1l[8] idin1l[7] idin1l[6] idin1l[5]
+ idin1l[4] idin1l[3] idin1l[2] idin1l[1] idin1l[0] lyaennn lyal0bl[67] lyal0bl[66]
+ lyal0bl[65] lyal0bl[64] lyal0bl[63] lyal0bl[62] lyal0bl[61] lyal0bl[60] lyal0bl[59]
+ lyal0bl[58] lyal0bl[57] lyal0bl[56] lyal0bl[55] lyal0bl[54] lyal0bl[53] lyal0bl[52]
+ lyal0bl[51] lyal0bl[50] lyal0bl[49] lyal0bl[48] lyal0bl[47] lyal0bl[46] lyal0bl[45]
+ lyal0bl[44] lyal0bl[43] lyal0bl[42] lyal0bl[41] lyal0bl[40] lyal0bl[39] lyal0bl[38]
+ lyal0bl[37] lyal0bl[36] lyal0bl[35] lyal0bl[34] lyal0bl[33] lyal0bl[32] lyal0bl[31]
+ lyal0bl[30] lyal0bl[29] lyal0bl[28] lyal0bl[27] lyal0bl[26] lyal0bl[25] lyal0bl[24]
+ lyal0bl[23] lyal0bl[22] lyal0bl[21] lyal0bl[20] lyal0bl[19] lyal0bl[18] lyal0bl[17]
+ lyal0bl[16] lyal0bl[15] lyal0bl[14] lyal0bl[13] lyal0bl[12] lyal0bl[11] lyal0bl[10]
+ lyal0bl[9] lyal0bl[8] lyal0bl[7] lyal0bl[6] lyal0bl[5] lyal0bl[4] lyal0bl[3] lyal0bl[2]
+ lyal0bl[1] lyal0bl[0] lyal0blnn[67] lyal0blnn[66] lyal0blnn[65] lyal0blnn[64]
+ lyal0blnn[63] lyal0blnn[62] lyal0blnn[61] lyal0blnn[60] lyal0blnn[59] lyal0blnn[58]
+ lyal0blnn[57] lyal0blnn[56] lyal0blnn[55] lyal0blnn[54] lyal0blnn[53] lyal0blnn[52]
+ lyal0blnn[51] lyal0blnn[50] lyal0blnn[49] lyal0blnn[48] lyal0blnn[47] lyal0blnn[46]
+ lyal0blnn[45] lyal0blnn[44] lyal0blnn[43] lyal0blnn[42] lyal0blnn[41] lyal0blnn[40]
+ lyal0blnn[39] lyal0blnn[38] lyal0blnn[37] lyal0blnn[36] lyal0blnn[35] lyal0blnn[34]
+ lyal0blnn[33] lyal0blnn[32] lyal0blnn[31] lyal0blnn[30] lyal0blnn[29] lyal0blnn[28]
+ lyal0blnn[27] lyal0blnn[26] lyal0blnn[25] lyal0blnn[24] lyal0blnn[23] lyal0blnn[22]
+ lyal0blnn[21] lyal0blnn[20] lyal0blnn[19] lyal0blnn[18] lyal0blnn[17] lyal0blnn[16]
+ lyal0blnn[15] lyal0blnn[14] lyal0blnn[13] lyal0blnn[12] lyal0blnn[11] lyal0blnn[10]
+ lyal0blnn[9] lyal0blnn[8] lyal0blnn[7] lyal0blnn[6] lyal0blnn[5] lyal0blnn[4]
+ lyal0blnn[3] lyal0blnn[2] lyal0blnn[1] lyal0blnn[0] nbl_kicknn_dn pcnn0_dn pcnn1_dn
+ rddataout[67] rddataout[66] rddataout[65] rddataout[64] rddataout[63] rddataout[62]
+ rddataout[61] rddataout[60] rddataout[59] rddataout[58] rddataout[57] rddataout[56]
+ rddataout[55] rddataout[54] rddataout[53] rddataout[52] rddataout[51] rddataout[50]
+ rddataout[49] rddataout[48] rddataout[47] rddataout[46] rddataout[45] rddataout[44]
+ rddataout[43] rddataout[42] rddataout[41] rddataout[40] rddataout[39] rddataout[38]
+ rddataout[37] rddataout[36] rddataout[35] rddataout[34] rddataout[33] rddataout[32]
+ rddataout[31] rddataout[30] rddataout[29] rddataout[28] rddataout[27] rddataout[26]
+ rddataout[25] rddataout[24] rddataout[23] rddataout[22] rddataout[21] rddataout[20]
+ rddataout[19] rddataout[18] rddataout[17] rddataout[16] rddataout[15] rddataout[14]
+ rddataout[13] rddataout[12] rddataout[11] rddataout[10] rddataout[9] rddataout[8]
+ rddataout[7] rddataout[6] rddataout[5] rddataout[4] rddataout[3] rddataout[2]
+ rddataout[1] rddataout[0] rdysel0_dn[3] rdysel0_dn[2] rdysel0_dn[1] rdysel0_dn[0]
+ rdysel1_dn[3] rdysel1_dn[2] rdysel1_dn[1] rdysel1_dn[0] redwl0_dn[1] redwl0_dn[0]
+ redwl1_dn[1] redwl1_dn[0] saenn_dn sapchnn_dn vcc vss waenn_dn[2] waenn_dn[1]
+ waenn_dn[0] wl0_dn[255] wl0_dn[254] wl0_dn[253] wl0_dn[252] wl0_dn[251] wl0_dn[250]
+ wl0_dn[249] wl0_dn[248] wl0_dn[247] wl0_dn[246] wl0_dn[245] wl0_dn[244] wl0_dn[243]
+ wl0_dn[242] wl0_dn[241] wl0_dn[240] wl0_dn[239] wl0_dn[238] wl0_dn[237] wl0_dn[236]
+ wl0_dn[235] wl0_dn[234] wl0_dn[233] wl0_dn[232] wl0_dn[231] wl0_dn[230] wl0_dn[229]
+ wl0_dn[228] wl0_dn[227] wl0_dn[226] wl0_dn[225] wl0_dn[224] wl0_dn[223] wl0_dn[222]
+ wl0_dn[221] wl0_dn[220] wl0_dn[219] wl0_dn[218] wl0_dn[217] wl0_dn[216] wl0_dn[215]
+ wl0_dn[214] wl0_dn[213] wl0_dn[212] wl0_dn[211] wl0_dn[210] wl0_dn[209] wl0_dn[208]
+ wl0_dn[207] wl0_dn[206] wl0_dn[205] wl0_dn[204] wl0_dn[203] wl0_dn[202] wl0_dn[201]
+ wl0_dn[200] wl0_dn[199] wl0_dn[198] wl0_dn[197] wl0_dn[196] wl0_dn[195] wl0_dn[194]
+ wl0_dn[193] wl0_dn[192] wl0_dn[191] wl0_dn[190] wl0_dn[189] wl0_dn[188] wl0_dn[187]
+ wl0_dn[186] wl0_dn[185] wl0_dn[184] wl0_dn[183] wl0_dn[182] wl0_dn[181] wl0_dn[180]
+ wl0_dn[179] wl0_dn[178] wl0_dn[177] wl0_dn[176] wl0_dn[175] wl0_dn[174] wl0_dn[173]
+ wl0_dn[172] wl0_dn[171] wl0_dn[170] wl0_dn[169] wl0_dn[168] wl0_dn[167] wl0_dn[166]
+ wl0_dn[165] wl0_dn[164] wl0_dn[163] wl0_dn[162] wl0_dn[161] wl0_dn[160] wl0_dn[159]
+ wl0_dn[158] wl0_dn[157] wl0_dn[156] wl0_dn[155] wl0_dn[154] wl0_dn[153] wl0_dn[152]
+ wl0_dn[151] wl0_dn[150] wl0_dn[149] wl0_dn[148] wl0_dn[147] wl0_dn[146] wl0_dn[145]
+ wl0_dn[144] wl0_dn[143] wl0_dn[142] wl0_dn[141] wl0_dn[140] wl0_dn[139] wl0_dn[138]
+ wl0_dn[137] wl0_dn[136] wl0_dn[135] wl0_dn[134] wl0_dn[133] wl0_dn[132] wl0_dn[131]
+ wl0_dn[130] wl0_dn[129] wl0_dn[128] wl0_dn[127] wl0_dn[126] wl0_dn[125] wl0_dn[124]
+ wl0_dn[123] wl0_dn[122] wl0_dn[121] wl0_dn[120] wl0_dn[119] wl0_dn[118] wl0_dn[117]
+ wl0_dn[116] wl0_dn[115] wl0_dn[114] wl0_dn[113] wl0_dn[112] wl0_dn[111] wl0_dn[110]
+ wl0_dn[109] wl0_dn[108] wl0_dn[107] wl0_dn[106] wl0_dn[105] wl0_dn[104] wl0_dn[103]
+ wl0_dn[102] wl0_dn[101] wl0_dn[100] wl0_dn[99] wl0_dn[98] wl0_dn[97] wl0_dn[96]
+ wl0_dn[95] wl0_dn[94] wl0_dn[93] wl0_dn[92] wl0_dn[91] wl0_dn[90] wl0_dn[89] wl0_dn[88]
+ wl0_dn[87] wl0_dn[86] wl0_dn[85] wl0_dn[84] wl0_dn[83] wl0_dn[82] wl0_dn[81] wl0_dn[80]
+ wl0_dn[79] wl0_dn[78] wl0_dn[77] wl0_dn[76] wl0_dn[75] wl0_dn[74] wl0_dn[73] wl0_dn[72]
+ wl0_dn[71] wl0_dn[70] wl0_dn[69] wl0_dn[68] wl0_dn[67] wl0_dn[66] wl0_dn[65] wl0_dn[64]
+ wl0_dn[63] wl0_dn[62] wl0_dn[61] wl0_dn[60] wl0_dn[59] wl0_dn[58] wl0_dn[57] wl0_dn[56]
+ wl0_dn[55] wl0_dn[54] wl0_dn[53] wl0_dn[52] wl0_dn[51] wl0_dn[50] wl0_dn[49] wl0_dn[48]
+ wl0_dn[47] wl0_dn[46] wl0_dn[45] wl0_dn[44] wl0_dn[43] wl0_dn[42] wl0_dn[41] wl0_dn[40]
+ wl0_dn[39] wl0_dn[38] wl0_dn[37] wl0_dn[36] wl0_dn[35] wl0_dn[34] wl0_dn[33] wl0_dn[32]
+ wl0_dn[31] wl0_dn[30] wl0_dn[29] wl0_dn[28] wl0_dn[27] wl0_dn[26] wl0_dn[25] wl0_dn[24]
+ wl0_dn[23] wl0_dn[22] wl0_dn[21] wl0_dn[20] wl0_dn[19] wl0_dn[18] wl0_dn[17] wl0_dn[16]
+ wl0_dn[15] wl0_dn[14] wl0_dn[13] wl0_dn[12] wl0_dn[11] wl0_dn[10] wl0_dn[9] wl0_dn[8]
+ wl0_dn[7] wl0_dn[6] wl0_dn[5] wl0_dn[4] wl0_dn[3] wl0_dn[2] wl0_dn[1] wl0_dn[0]
+ wl1_dn[255] wl1_dn[254] wl1_dn[253] wl1_dn[252] wl1_dn[251] wl1_dn[250] wl1_dn[249]
+ wl1_dn[248] wl1_dn[247] wl1_dn[246] wl1_dn[245] wl1_dn[244] wl1_dn[243] wl1_dn[242]
+ wl1_dn[241] wl1_dn[240] wl1_dn[239] wl1_dn[238] wl1_dn[237] wl1_dn[236] wl1_dn[235]
+ wl1_dn[234] wl1_dn[233] wl1_dn[232] wl1_dn[231] wl1_dn[230] wl1_dn[229] wl1_dn[228]
+ wl1_dn[227] wl1_dn[226] wl1_dn[225] wl1_dn[224] wl1_dn[223] wl1_dn[222] wl1_dn[221]
+ wl1_dn[220] wl1_dn[219] wl1_dn[218] wl1_dn[217] wl1_dn[216] wl1_dn[215] wl1_dn[214]
+ wl1_dn[213] wl1_dn[212] wl1_dn[211] wl1_dn[210] wl1_dn[209] wl1_dn[208] wl1_dn[207]
+ wl1_dn[206] wl1_dn[205] wl1_dn[204] wl1_dn[203] wl1_dn[202] wl1_dn[201] wl1_dn[200]
+ wl1_dn[199] wl1_dn[198] wl1_dn[197] wl1_dn[196] wl1_dn[195] wl1_dn[194] wl1_dn[193]
+ wl1_dn[192] wl1_dn[191] wl1_dn[190] wl1_dn[189] wl1_dn[188] wl1_dn[187] wl1_dn[186]
+ wl1_dn[185] wl1_dn[184] wl1_dn[183] wl1_dn[182] wl1_dn[181] wl1_dn[180] wl1_dn[179]
+ wl1_dn[178] wl1_dn[177] wl1_dn[176] wl1_dn[175] wl1_dn[174] wl1_dn[173] wl1_dn[172]
+ wl1_dn[171] wl1_dn[170] wl1_dn[169] wl1_dn[168] wl1_dn[167] wl1_dn[166] wl1_dn[165]
+ wl1_dn[164] wl1_dn[163] wl1_dn[162] wl1_dn[161] wl1_dn[160] wl1_dn[159] wl1_dn[158]
+ wl1_dn[157] wl1_dn[156] wl1_dn[155] wl1_dn[154] wl1_dn[153] wl1_dn[152] wl1_dn[151]
+ wl1_dn[150] wl1_dn[149] wl1_dn[148] wl1_dn[147] wl1_dn[146] wl1_dn[145] wl1_dn[144]
+ wl1_dn[143] wl1_dn[142] wl1_dn[141] wl1_dn[140] wl1_dn[139] wl1_dn[138] wl1_dn[137]
+ wl1_dn[136] wl1_dn[135] wl1_dn[134] wl1_dn[133] wl1_dn[132] wl1_dn[131] wl1_dn[130]
+ wl1_dn[129] wl1_dn[128] wl1_dn[127] wl1_dn[126] wl1_dn[125] wl1_dn[124] wl1_dn[123]
+ wl1_dn[122] wl1_dn[121] wl1_dn[120] wl1_dn[119] wl1_dn[118] wl1_dn[117] wl1_dn[116]
+ wl1_dn[115] wl1_dn[114] wl1_dn[113] wl1_dn[112] wl1_dn[111] wl1_dn[110] wl1_dn[109]
+ wl1_dn[108] wl1_dn[107] wl1_dn[106] wl1_dn[105] wl1_dn[104] wl1_dn[103] wl1_dn[102]
+ wl1_dn[101] wl1_dn[100] wl1_dn[99] wl1_dn[98] wl1_dn[97] wl1_dn[96] wl1_dn[95]
+ wl1_dn[94] wl1_dn[93] wl1_dn[92] wl1_dn[91] wl1_dn[90] wl1_dn[89] wl1_dn[88] wl1_dn[87]
+ wl1_dn[86] wl1_dn[85] wl1_dn[84] wl1_dn[83] wl1_dn[82] wl1_dn[81] wl1_dn[80] wl1_dn[79]
+ wl1_dn[78] wl1_dn[77] wl1_dn[76] wl1_dn[75] wl1_dn[74] wl1_dn[73] wl1_dn[72] wl1_dn[71]
+ wl1_dn[70] wl1_dn[69] wl1_dn[68] wl1_dn[67] wl1_dn[66] wl1_dn[65] wl1_dn[64] wl1_dn[63]
+ wl1_dn[62] wl1_dn[61] wl1_dn[60] wl1_dn[59] wl1_dn[58] wl1_dn[57] wl1_dn[56] wl1_dn[55]
+ wl1_dn[54] wl1_dn[53] wl1_dn[52] wl1_dn[51] wl1_dn[50] wl1_dn[49] wl1_dn[48] wl1_dn[47]
+ wl1_dn[46] wl1_dn[45] wl1_dn[44] wl1_dn[43] wl1_dn[42] wl1_dn[41] wl1_dn[40] wl1_dn[39]
+ wl1_dn[38] wl1_dn[37] wl1_dn[36] wl1_dn[35] wl1_dn[34] wl1_dn[33] wl1_dn[32] wl1_dn[31]
+ wl1_dn[30] wl1_dn[29] wl1_dn[28] wl1_dn[27] wl1_dn[26] wl1_dn[25] wl1_dn[24] wl1_dn[23]
+ wl1_dn[22] wl1_dn[21] wl1_dn[20] wl1_dn[19] wl1_dn[18] wl1_dn[17] wl1_dn[16] wl1_dn[15]
+ wl1_dn[14] wl1_dn[13] wl1_dn[12] wl1_dn[11] wl1_dn[10] wl1_dn[9] wl1_dn[8] wl1_dn[7]
+ wl1_dn[6] wl1_dn[5] wl1_dn[4] wl1_dn[3] wl1_dn[2] wl1_dn[1] wl1_dn[0] wrclk_dn
+ wrcolsel0_dn[3] wrcolsel0_dn[2] wrcolsel0_dn[1] wrcolsel0_dn[0] wrcolsel1_dn[3]
+ wrcolsel1_dn[2] wrcolsel1_dn[1] wrcolsel1_dn[0] wrdataen_dn ip78d6hcf2sr4096x135m4i2k4w8r2lya_bank_dn
.ENDS

.SUBCKT ip78d6hcf2sr4096x135m4i2k4w8r2lya clk fz_asynckick fz_asyncrd fz_asyncwr
+ fz_clkgate fz_finekick[3] fz_finekick[2] fz_finekick[1] fz_finekick[0] fz_rassel[2]
+ fz_rassel[1] fz_rassel[0] fz_rdwlcut fz_rdwlpw[3] fz_rdwlpw[2] fz_rdwlpw[1] fz_rdwlpw[0]
+ fz_saepw[1] fz_saepw[0] fz_trbwassel[2] fz_trbwassel[1] fz_trbwassel[0] fz_trkwllvl[2]
+ fz_trkwllvl[1] fz_trkwllvl[0] fz_wassel[2] fz_wassel[1] fz_wassel[0] fz_wrwlcut
+ fz_wrwlpw[1] fz_wrwlpw[0] grant ia[8] ia[7] ia[6] ia[5] ia[4] ia[3] ia[2] ia[1]
+ ia[0] idin[134] idin[133] idin[132] idin[131] idin[130] idin[129] idin[128] idin[127]
+ idin[126] idin[125] idin[124] idin[123] idin[122] idin[121] idin[120] idin[119]
+ idin[118] idin[117] idin[116] idin[115] idin[114] idin[113] idin[112] idin[111]
+ idin[110] idin[109] idin[108] idin[107] idin[106] idin[105] idin[104] idin[103]
+ idin[102] idin[101] idin[100] idin[99] idin[98] idin[97] idin[96] idin[95] idin[94]
+ idin[93] idin[92] idin[91] idin[90] idin[89] idin[88] idin[87] idin[86] idin[85]
+ idin[84] idin[83] idin[82] idin[81] idin[80] idin[79] idin[78] idin[77] idin[76]
+ idin[75] idin[74] idin[73] idin[72] idin[71] idin[70] idin[69] idin[68] idin[67]
+ idin[66] idin[65] idin[64] idin[63] idin[62] idin[61] idin[60] idin[59] idin[58]
+ idin[57] idin[56] idin[55] idin[54] idin[53] idin[52] idin[51] idin[50] idin[49]
+ idin[48] idin[47] idin[46] idin[45] idin[44] idin[43] idin[42] idin[41] idin[40]
+ idin[39] idin[38] idin[37] idin[36] idin[35] idin[34] idin[33] idin[32] idin[31]
+ idin[30] idin[29] idin[28] idin[27] idin[26] idin[25] idin[24] idin[23] idin[22]
+ idin[21] idin[20] idin[19] idin[18] idin[17] idin[16] idin[15] idin[14] idin[13]
+ idin[12] idin[11] idin[10] idin[9] idin[8] idin[7] idin[6] idin[5] idin[4] idin[3]
+ idin[2] idin[1] idin[0] irowredun[1] irowredun[0] iway[7] iway[6] iway[5] iway[4]
+ iway[3] iway[2] iway[1] iway[0] iwen lyabnk lyaclkstop lyaen lyal2bl lyal2blnn
+ lyanowl odout[134] odout[133] odout[132] odout[131] odout[130] odout[129] odout[128]
+ odout[127] odout[126] odout[125] odout[124] odout[123] odout[122] odout[121] odout[120]
+ odout[119] odout[118] odout[117] odout[116] odout[115] odout[114] odout[113] odout[112]
+ odout[111] odout[110] odout[109] odout[108] odout[107] odout[106] odout[105] odout[104]
+ odout[103] odout[102] odout[101] odout[100] odout[99] odout[98] odout[97] odout[96]
+ odout[95] odout[94] odout[93] odout[92] odout[91] odout[90] odout[89] odout[88]
+ odout[87] odout[86] odout[85] odout[84] odout[83] odout[82] odout[81] odout[80]
+ odout[79] odout[78] odout[77] odout[76] odout[75] odout[74] odout[73] odout[72]
+ odout[71] odout[70] odout[69] odout[68] odout[67] odout[66] odout[65] odout[64]
+ odout[63] odout[62] odout[61] odout[60] odout[59] odout[58] odout[57] odout[56]
+ odout[55] odout[54] odout[53] odout[52] odout[51] odout[50] odout[49] odout[48]
+ odout[47] odout[46] odout[45] odout[44] odout[43] odout[42] odout[41] odout[40]
+ odout[39] odout[38] odout[37] odout[36] odout[35] odout[34] odout[33] odout[32]
+ odout[31] odout[30] odout[29] odout[28] odout[27] odout[26] odout[25] odout[24]
+ odout[23] odout[22] odout[21] odout[20] odout[19] odout[18] odout[17] odout[16]
+ odout[15] odout[14] odout[13] odout[12] odout[11] odout[10] odout[9] odout[8]
+ odout[7] odout[6] odout[5] odout[4] odout[3] odout[2] odout[1] odout[0] turbomode
+ vcc vss
*.PININFO clk:I fz_asynckick:I fz_asyncrd:I fz_asyncwr:I fz_clkgate:I fz_finekick[3]:I fz_finekick[2]:I fz_finekick[1]:I fz_finekick[0]:I fz_rassel[2]:I fz_rassel[1]:I fz_rassel[0]:I fz_rdwlcut:I fz_rdwlpw[3]:I fz_rdwlpw[2]:I fz_rdwlpw[1]:I fz_rdwlpw[0]:I fz_saepw[1]:I fz_saepw[0]:I fz_trbwassel[2]:I
*.PININFO fz_trbwassel[1]:I fz_trbwassel[0]:I fz_trkwllvl[2]:I fz_trkwllvl[1]:I fz_trkwllvl[0]:I fz_wassel[2]:I fz_wassel[1]:I fz_wassel[0]:I fz_wrwlcut:I fz_wrwlpw[1]:I fz_wrwlpw[0]:I grant:I ia[8]:I ia[7]:I ia[6]:I ia[5]:I ia[4]:I ia[3]:I ia[2]:I ia[1]:I
*.PININFO ia[0]:I idin[134]:I idin[133]:I idin[132]:I idin[131]:I idin[130]:I idin[129]:I idin[128]:I idin[127]:I idin[126]:I idin[125]:I idin[124]:I idin[123]:I idin[122]:I idin[121]:I idin[120]:I idin[119]:I idin[118]:I idin[117]:I idin[116]:I
*.PININFO idin[115]:I idin[114]:I idin[113]:I idin[112]:I idin[111]:I idin[110]:I idin[109]:I idin[108]:I idin[107]:I idin[106]:I idin[105]:I idin[104]:I idin[103]:I idin[102]:I idin[101]:I idin[100]:I idin[99]:I idin[98]:I idin[97]:I idin[96]:I
*.PININFO idin[95]:I idin[94]:I idin[93]:I idin[92]:I idin[91]:I idin[90]:I idin[89]:I idin[88]:I idin[87]:I idin[86]:I idin[85]:I idin[84]:I idin[83]:I idin[82]:I idin[81]:I idin[80]:I idin[79]:I idin[78]:I idin[77]:I idin[76]:I
*.PININFO idin[75]:I idin[74]:I idin[73]:I idin[72]:I idin[71]:I idin[70]:I idin[69]:I idin[68]:I idin[67]:I idin[66]:I idin[65]:I idin[64]:I idin[63]:I idin[62]:I idin[61]:I idin[60]:I idin[59]:I idin[58]:I idin[57]:I idin[56]:I
*.PININFO idin[55]:I idin[54]:I idin[53]:I idin[52]:I idin[51]:I idin[50]:I idin[49]:I idin[48]:I idin[47]:I idin[46]:I idin[45]:I idin[44]:I idin[43]:I idin[42]:I idin[41]:I idin[40]:I idin[39]:I idin[38]:I idin[37]:I idin[36]:I
*.PININFO idin[35]:I idin[34]:I idin[33]:I idin[32]:I idin[31]:I idin[30]:I idin[29]:I idin[28]:I idin[27]:I idin[26]:I idin[25]:I idin[24]:I idin[23]:I idin[22]:I idin[21]:I idin[20]:I idin[19]:I idin[18]:I idin[17]:I idin[16]:I
*.PININFO idin[15]:I idin[14]:I idin[13]:I idin[12]:I idin[11]:I idin[10]:I idin[9]:I idin[8]:I idin[7]:I idin[6]:I idin[5]:I idin[4]:I idin[3]:I idin[2]:I idin[1]:I idin[0]:I irowredun[1]:I irowredun[0]:I iway[7]:I iway[6]:I
*.PININFO iway[5]:I iway[4]:I iway[3]:I iway[2]:I iway[1]:I iway[0]:I iwen:I lyabnk:I lyaclkstop:I lyaen:I lyal2bl:I lyal2blnn:I lyanowl:I odout[134]:O odout[133]:O odout[132]:O odout[131]:O odout[130]:O odout[129]:O odout[128]:O
*.PININFO odout[127]:O odout[126]:O odout[125]:O odout[124]:O odout[123]:O odout[122]:O odout[121]:O odout[120]:O odout[119]:O odout[118]:O odout[117]:O odout[116]:O odout[115]:O odout[114]:O odout[113]:O odout[112]:O odout[111]:O odout[110]:O odout[109]:O odout[108]:O
*.PININFO odout[107]:O odout[106]:O odout[105]:O odout[104]:O odout[103]:O odout[102]:O odout[101]:O odout[100]:O odout[99]:O odout[98]:O odout[97]:O odout[96]:O odout[95]:O odout[94]:O odout[93]:O odout[92]:O odout[91]:O odout[90]:O odout[89]:O odout[88]:O
*.PININFO odout[87]:O odout[86]:O odout[85]:O odout[84]:O odout[83]:O odout[82]:O odout[81]:O odout[80]:O odout[79]:O odout[78]:O odout[77]:O odout[76]:O odout[75]:O odout[74]:O odout[73]:O odout[72]:O odout[71]:O odout[70]:O odout[69]:O odout[68]:O
*.PININFO odout[67]:O odout[66]:O odout[65]:O odout[64]:O odout[63]:O odout[62]:O odout[61]:O odout[60]:O odout[59]:O odout[58]:O odout[57]:O odout[56]:O odout[55]:O odout[54]:O odout[53]:O odout[52]:O odout[51]:O odout[50]:O odout[49]:O odout[48]:O
*.PININFO odout[47]:O odout[46]:O odout[45]:O odout[44]:O odout[43]:O odout[42]:O odout[41]:O odout[40]:O odout[39]:O odout[38]:O odout[37]:O odout[36]:O odout[35]:O odout[34]:O odout[33]:O odout[32]:O odout[31]:O odout[30]:O odout[29]:O odout[28]:O
*.PININFO odout[27]:O odout[26]:O odout[25]:O odout[24]:O odout[23]:O odout[22]:O odout[21]:O odout[20]:O odout[19]:O odout[18]:O odout[17]:O odout[16]:O odout[15]:O odout[14]:O odout[13]:O odout[12]:O odout[11]:O odout[10]:O odout[9]:O odout[8]:O
*.PININFO odout[7]:O odout[6]:O odout[5]:O odout[4]:O odout[3]:O odout[2]:O odout[1]:O odout[0]:O turbomode:I vcc:I vss:I
Xgio activered#[1] activered#[0] bankgrant1h[1] bankgrant1h[0] bankgrant1l[1] bankgrant1l[0]
+ bankgrant2h[1] bankgrant2h[0] clk clkbank fz_asynckick fz_asynckick# fz_asyncrd
+ fz_asyncrd# fz_asyncwr fz_asyncwr# fz_clkgate fz_finekick[3] fz_finekick[2] fz_finekick[1]
+ fz_finekick[0] fz_finekick#[3] fz_finekick#[2] fz_finekick#[1] fz_finekick#[0]
+ fz_rassel[2] fz_rassel[1] fz_rassel[0] fz_rassel#[2] fz_rassel#[1] fz_rassel#[0]
+ fz_rdwlcut fz_rdwlcut# fz_rdwlpw[3] fz_rdwlpw[2] fz_rdwlpw[1] fz_rdwlpw[0] fz_rdwlpw#[3]
+ fz_rdwlpw#[2] fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw[1] fz_saepw[0] fz_saepw#[1]
+ fz_saepw#[0] fz_trbwassel[2] fz_trbwassel[1] fz_trbwassel[0] fz_trbwassel#[2]
+ fz_trbwassel#[1] fz_trbwassel#[0] fz_trkwllvl[2] fz_trkwllvl[1] fz_trkwllvl[0]
+ fz_trkwllvl#[2] fz_trkwllvl#[1] fz_trkwllvl#[0] fz_wassel[2] fz_wassel[1] fz_wassel[0]
+ fz_wassel#[2] fz_wassel#[1] fz_wassel#[0] fz_wrwlcut fz_wrwlcut# fz_wrwlpw[1]
+ fz_wrwlpw[0] fz_wrwlpw#[1] fz_wrwlpw#[0] grant ia[8] ia[7] ia[6] ia[5] ia[4] ia[3]
+ ia[2] ia[1] ia[0] ia_hi#[2] ia_hi#[1] ia_hi#[0] ia_mid#[2] ia_mid#[1] ia_mid#[0]
+ ia_wle#[1] ia_wle#[0] idin[134] idin[133] idin[132] idin[131] idin[130] idin[129]
+ idin[128] idin[127] idin[126] idin[125] idin[124] idin[123] idin[122] idin[121]
+ idin[120] idin[119] idin[118] idin[117] idin[116] idin[115] idin[114] idin[113]
+ idin[112] idin[111] idin[110] idin[109] idin[108] idin[107] idin[106] idin[105]
+ idin[104] idin[103] idin[102] idin[101] idin[100] idin[99] idin[98] idin[97] idin[96]
+ idin[95] idin[94] idin[93] idin[92] idin[91] idin[90] idin[89] idin[88] idin[87]
+ idin[86] idin[85] idin[84] idin[83] idin[82] idin[81] idin[80] idin[79] idin[78]
+ idin[77] idin[76] idin[75] idin[74] idin[73] idin[72] idin[71] idin[70] idin[69]
+ idin[68] idin[67] idin[66] idin[65] idin[64] idin[63] idin[62] idin[61] idin[60]
+ idin[59] idin[58] idin[57] idin[56] idin[55] idin[54] idin[53] idin[52] idin[51]
+ idin[50] idin[49] idin[48] idin[47] idin[46] idin[45] idin[44] idin[43] idin[42]
+ idin[41] idin[40] idin[39] idin[38] idin[37] idin[36] idin[35] idin[34] idin[33]
+ idin[32] idin[31] idin[30] idin[29] idin[28] idin[27] idin[26] idin[25] idin[24]
+ idin[23] idin[22] idin[21] idin[20] idin[19] idin[18] idin[17] idin[16] idin[15]
+ idin[14] idin[13] idin[12] idin[11] idin[10] idin[9] idin[8] idin[7] idin[6] idin[5]
+ idin[4] idin[3] idin[2] idin[1] idin[0] idin1l[134] idin1l[133] idin1l[132] idin1l[131]
+ idin1l[130] idin1l[129] idin1l[128] idin1l[127] idin1l[126] idin1l[125] idin1l[124]
+ idin1l[123] idin1l[122] idin1l[121] idin1l[120] idin1l[119] idin1l[118] idin1l[117]
+ idin1l[116] idin1l[115] idin1l[114] idin1l[113] idin1l[112] idin1l[111] idin1l[110]
+ idin1l[109] idin1l[108] idin1l[107] idin1l[106] idin1l[105] idin1l[104] idin1l[103]
+ idin1l[102] idin1l[101] idin1l[100] idin1l[99] idin1l[98] idin1l[97] idin1l[96]
+ idin1l[95] idin1l[94] idin1l[93] idin1l[92] idin1l[91] idin1l[90] idin1l[89] idin1l[88]
+ idin1l[87] idin1l[86] idin1l[85] idin1l[84] idin1l[83] idin1l[82] idin1l[81] idin1l[80]
+ idin1l[79] idin1l[78] idin1l[77] idin1l[76] idin1l[75] idin1l[74] idin1l[73] idin1l[72]
+ idin1l[71] idin1l[70] idin1l[69] idin1l[68] idin1l[67] idin1l[66] idin1l[65] idin1l[64]
+ idin1l[63] idin1l[62] idin1l[61] idin1l[60] idin1l[59] idin1l[58] idin1l[57] idin1l[56]
+ idin1l[55] idin1l[54] idin1l[53] idin1l[52] idin1l[51] idin1l[50] idin1l[49] idin1l[48]
+ idin1l[47] idin1l[46] idin1l[45] idin1l[44] idin1l[43] idin1l[42] idin1l[41] idin1l[40]
+ idin1l[39] idin1l[38] idin1l[37] idin1l[36] idin1l[35] idin1l[34] idin1l[33] idin1l[32]
+ idin1l[31] idin1l[30] idin1l[29] idin1l[28] idin1l[27] idin1l[26] idin1l[25] idin1l[24]
+ idin1l[23] idin1l[22] idin1l[21] idin1l[20] idin1l[19] idin1l[18] idin1l[17] idin1l[16]
+ idin1l[15] idin1l[14] idin1l[13] idin1l[12] idin1l[11] idin1l[10] idin1l[9] idin1l[8]
+ idin1l[7] idin1l[6] idin1l[5] idin1l[4] idin1l[3] idin1l[2] idin1l[1] idin1l[0]
+ irowredun[1] irowredun[0] iway[7] iway[6] iway[5] iway[4] iway[3] iway[2] iway[1]
+ iway[0] iwen iwren1h iwren1l2l iwren2h3h lyabnk lyaclkstop lyaen lyal0bl[134]
+ lyal0bl[133] lyal0bl[132] lyal0bl[131] lyal0bl[130] lyal0bl[129] lyal0bl[128]
+ lyal0bl[127] lyal0bl[126] lyal0bl[125] lyal0bl[124] lyal0bl[123] lyal0bl[122]
+ lyal0bl[121] lyal0bl[120] lyal0bl[119] lyal0bl[118] lyal0bl[117] lyal0bl[116]
+ lyal0bl[115] lyal0bl[114] lyal0bl[113] lyal0bl[112] lyal0bl[111] lyal0bl[110]
+ lyal0bl[109] lyal0bl[108] lyal0bl[107] lyal0bl[106] lyal0bl[105] lyal0bl[104]
+ lyal0bl[103] lyal0bl[102] lyal0bl[101] lyal0bl[100] lyal0bl[99] lyal0bl[98] lyal0bl[97]
+ lyal0bl[96] lyal0bl[95] lyal0bl[94] lyal0bl[93] lyal0bl[92] lyal0bl[91] lyal0bl[90]
+ lyal0bl[89] lyal0bl[88] lyal0bl[87] lyal0bl[86] lyal0bl[85] lyal0bl[84] lyal0bl[83]
+ lyal0bl[82] lyal0bl[81] lyal0bl[80] lyal0bl[79] lyal0bl[78] lyal0bl[77] lyal0bl[76]
+ lyal0bl[75] lyal0bl[74] lyal0bl[73] lyal0bl[72] lyal0bl[71] lyal0bl[70] lyal0bl[69]
+ lyal0bl[68] lyal0bl[67] lyal0bl[66] lyal0bl[65] lyal0bl[64] lyal0bl[63] lyal0bl[62]
+ lyal0bl[61] lyal0bl[60] lyal0bl[59] lyal0bl[58] lyal0bl[57] lyal0bl[56] lyal0bl[55]
+ lyal0bl[54] lyal0bl[53] lyal0bl[52] lyal0bl[51] lyal0bl[50] lyal0bl[49] lyal0bl[48]
+ lyal0bl[47] lyal0bl[46] lyal0bl[45] lyal0bl[44] lyal0bl[43] lyal0bl[42] lyal0bl[41]
+ lyal0bl[40] lyal0bl[39] lyal0bl[38] lyal0bl[37] lyal0bl[36] lyal0bl[35] lyal0bl[34]
+ lyal0bl[33] lyal0bl[32] lyal0bl[31] lyal0bl[30] lyal0bl[29] lyal0bl[28] lyal0bl[27]
+ lyal0bl[26] lyal0bl[25] lyal0bl[24] lyal0bl[23] lyal0bl[22] lyal0bl[21] lyal0bl[20]
+ lyal0bl[19] lyal0bl[18] lyal0bl[17] lyal0bl[16] lyal0bl[15] lyal0bl[14] lyal0bl[13]
+ lyal0bl[12] lyal0bl[11] lyal0bl[10] lyal0bl[9] lyal0bl[8] lyal0bl[7] lyal0bl[6]
+ lyal0bl[5] lyal0bl[4] lyal0bl[3] lyal0bl[2] lyal0bl[1] lyal0bl[0] lyal0blnn[134]
+ lyal0blnn[133] lyal0blnn[132] lyal0blnn[131] lyal0blnn[130] lyal0blnn[129] lyal0blnn[128]
+ lyal0blnn[127] lyal0blnn[126] lyal0blnn[125] lyal0blnn[124] lyal0blnn[123] lyal0blnn[122]
+ lyal0blnn[121] lyal0blnn[120] lyal0blnn[119] lyal0blnn[118] lyal0blnn[117] lyal0blnn[116]
+ lyal0blnn[115] lyal0blnn[114] lyal0blnn[113] lyal0blnn[112] lyal0blnn[111] lyal0blnn[110]
+ lyal0blnn[109] lyal0blnn[108] lyal0blnn[107] lyal0blnn[106] lyal0blnn[105] lyal0blnn[104]
+ lyal0blnn[103] lyal0blnn[102] lyal0blnn[101] lyal0blnn[100] lyal0blnn[99] lyal0blnn[98]
+ lyal0blnn[97] lyal0blnn[96] lyal0blnn[95] lyal0blnn[94] lyal0blnn[93] lyal0blnn[92]
+ lyal0blnn[91] lyal0blnn[90] lyal0blnn[89] lyal0blnn[88] lyal0blnn[87] lyal0blnn[86]
+ lyal0blnn[85] lyal0blnn[84] lyal0blnn[83] lyal0blnn[82] lyal0blnn[81] lyal0blnn[80]
+ lyal0blnn[79] lyal0blnn[78] lyal0blnn[77] lyal0blnn[76] lyal0blnn[75] lyal0blnn[74]
+ lyal0blnn[73] lyal0blnn[72] lyal0blnn[71] lyal0blnn[70] lyal0blnn[69] lyal0blnn[68]
+ lyal0blnn[67] lyal0blnn[66] lyal0blnn[65] lyal0blnn[64] lyal0blnn[63] lyal0blnn[62]
+ lyal0blnn[61] lyal0blnn[60] lyal0blnn[59] lyal0blnn[58] lyal0blnn[57] lyal0blnn[56]
+ lyal0blnn[55] lyal0blnn[54] lyal0blnn[53] lyal0blnn[52] lyal0blnn[51] lyal0blnn[50]
+ lyal0blnn[49] lyal0blnn[48] lyal0blnn[47] lyal0blnn[46] lyal0blnn[45] lyal0blnn[44]
+ lyal0blnn[43] lyal0blnn[42] lyal0blnn[41] lyal0blnn[40] lyal0blnn[39] lyal0blnn[38]
+ lyal0blnn[37] lyal0blnn[36] lyal0blnn[35] lyal0blnn[34] lyal0blnn[33] lyal0blnn[32]
+ lyal0blnn[31] lyal0blnn[30] lyal0blnn[29] lyal0blnn[28] lyal0blnn[27] lyal0blnn[26]
+ lyal0blnn[25] lyal0blnn[24] lyal0blnn[23] lyal0blnn[22] lyal0blnn[21] lyal0blnn[20]
+ lyal0blnn[19] lyal0blnn[18] lyal0blnn[17] lyal0blnn[16] lyal0blnn[15] lyal0blnn[14]
+ lyal0blnn[13] lyal0blnn[12] lyal0blnn[11] lyal0blnn[10] lyal0blnn[9] lyal0blnn[8]
+ lyal0blnn[7] lyal0blnn[6] lyal0blnn[5] lyal0blnn[4] lyal0blnn[3] lyal0blnn[2]
+ lyal0blnn[1] lyal0blnn[0] lyal2bl lyal2blnn lyanowl lyanowl# lyaseltmr odout[134]
+ odout[133] odout[132] odout[131] odout[130] odout[129] odout[128] odout[127] odout[126]
+ odout[125] odout[124] odout[123] odout[122] odout[121] odout[120] odout[119] odout[118]
+ odout[117] odout[116] odout[115] odout[114] odout[113] odout[112] odout[111] odout[110]
+ odout[109] odout[108] odout[107] odout[106] odout[105] odout[104] odout[103] odout[102]
+ odout[101] odout[100] odout[99] odout[98] odout[97] odout[96] odout[95] odout[94]
+ odout[93] odout[92] odout[91] odout[90] odout[89] odout[88] odout[87] odout[86]
+ odout[85] odout[84] odout[83] odout[82] odout[81] odout[80] odout[79] odout[78]
+ odout[77] odout[76] odout[75] odout[74] odout[73] odout[72] odout[71] odout[70]
+ odout[69] odout[68] odout[67] odout[66] odout[65] odout[64] odout[63] odout[62]
+ odout[61] odout[60] odout[59] odout[58] odout[57] odout[56] odout[55] odout[54]
+ odout[53] odout[52] odout[51] odout[50] odout[49] odout[48] odout[47] odout[46]
+ odout[45] odout[44] odout[43] odout[42] odout[41] odout[40] odout[39] odout[38]
+ odout[37] odout[36] odout[35] odout[34] odout[33] odout[32] odout[31] odout[30]
+ odout[29] odout[28] odout[27] odout[26] odout[25] odout[24] odout[23] odout[22]
+ odout[21] odout[20] odout[19] odout[18] odout[17] odout[16] odout[15] odout[14]
+ odout[13] odout[12] odout[11] odout[10] odout[9] odout[8] odout[7] odout[6] odout[5]
+ odout[4] odout[3] odout[2] odout[1] odout[0] rddataout_0[134] rddataout_0[133]
+ rddataout_0[132] rddataout_0[131] rddataout_0[130] rddataout_0[129] rddataout_0[128]
+ rddataout_0[127] rddataout_0[126] rddataout_0[125] rddataout_0[124] rddataout_0[123]
+ rddataout_0[122] rddataout_0[121] rddataout_0[120] rddataout_0[119] rddataout_0[118]
+ rddataout_0[117] rddataout_0[116] rddataout_0[115] rddataout_0[114] rddataout_0[113]
+ rddataout_0[112] rddataout_0[111] rddataout_0[110] rddataout_0[109] rddataout_0[108]
+ rddataout_0[107] rddataout_0[106] rddataout_0[105] rddataout_0[104] rddataout_0[103]
+ rddataout_0[102] rddataout_0[101] rddataout_0[100] rddataout_0[99] rddataout_0[98]
+ rddataout_0[97] rddataout_0[96] rddataout_0[95] rddataout_0[94] rddataout_0[93]
+ rddataout_0[92] rddataout_0[91] rddataout_0[90] rddataout_0[89] rddataout_0[88]
+ rddataout_0[87] rddataout_0[86] rddataout_0[85] rddataout_0[84] rddataout_0[83]
+ rddataout_0[82] rddataout_0[81] rddataout_0[80] rddataout_0[79] rddataout_0[78]
+ rddataout_0[77] rddataout_0[76] rddataout_0[75] rddataout_0[74] rddataout_0[73]
+ rddataout_0[72] rddataout_0[71] rddataout_0[70] rddataout_0[69] rddataout_0[68]
+ rddataout_0[67] rddataout_0[66] rddataout_0[65] rddataout_0[64] rddataout_0[63]
+ rddataout_0[62] rddataout_0[61] rddataout_0[60] rddataout_0[59] rddataout_0[58]
+ rddataout_0[57] rddataout_0[56] rddataout_0[55] rddataout_0[54] rddataout_0[53]
+ rddataout_0[52] rddataout_0[51] rddataout_0[50] rddataout_0[49] rddataout_0[48]
+ rddataout_0[47] rddataout_0[46] rddataout_0[45] rddataout_0[44] rddataout_0[43]
+ rddataout_0[42] rddataout_0[41] rddataout_0[40] rddataout_0[39] rddataout_0[38]
+ rddataout_0[37] rddataout_0[36] rddataout_0[35] rddataout_0[34] rddataout_0[33]
+ rddataout_0[32] rddataout_0[31] rddataout_0[30] rddataout_0[29] rddataout_0[28]
+ rddataout_0[27] rddataout_0[26] rddataout_0[25] rddataout_0[24] rddataout_0[23]
+ rddataout_0[22] rddataout_0[21] rddataout_0[20] rddataout_0[19] rddataout_0[18]
+ rddataout_0[17] rddataout_0[16] rddataout_0[15] rddataout_0[14] rddataout_0[13]
+ rddataout_0[12] rddataout_0[11] rddataout_0[10] rddataout_0[9] rddataout_0[8]
+ rddataout_0[7] rddataout_0[6] rddataout_0[5] rddataout_0[4] rddataout_0[3] rddataout_0[2]
+ rddataout_0[1] rddataout_0[0] rddataout_1[134] rddataout_1[133] rddataout_1[132]
+ rddataout_1[131] rddataout_1[130] rddataout_1[129] rddataout_1[128] rddataout_1[127]
+ rddataout_1[126] rddataout_1[125] rddataout_1[124] rddataout_1[123] rddataout_1[122]
+ rddataout_1[121] rddataout_1[120] rddataout_1[119] rddataout_1[118] rddataout_1[117]
+ rddataout_1[116] rddataout_1[115] rddataout_1[114] rddataout_1[113] rddataout_1[112]
+ rddataout_1[111] rddataout_1[110] rddataout_1[109] rddataout_1[108] rddataout_1[107]
+ rddataout_1[106] rddataout_1[105] rddataout_1[104] rddataout_1[103] rddataout_1[102]
+ rddataout_1[101] rddataout_1[100] rddataout_1[99] rddataout_1[98] rddataout_1[97]
+ rddataout_1[96] rddataout_1[95] rddataout_1[94] rddataout_1[93] rddataout_1[92]
+ rddataout_1[91] rddataout_1[90] rddataout_1[89] rddataout_1[88] rddataout_1[87]
+ rddataout_1[86] rddataout_1[85] rddataout_1[84] rddataout_1[83] rddataout_1[82]
+ rddataout_1[81] rddataout_1[80] rddataout_1[79] rddataout_1[78] rddataout_1[77]
+ rddataout_1[76] rddataout_1[75] rddataout_1[74] rddataout_1[73] rddataout_1[72]
+ rddataout_1[71] rddataout_1[70] rddataout_1[69] rddataout_1[68] rddataout_1[67]
+ rddataout_1[66] rddataout_1[65] rddataout_1[64] rddataout_1[63] rddataout_1[62]
+ rddataout_1[61] rddataout_1[60] rddataout_1[59] rddataout_1[58] rddataout_1[57]
+ rddataout_1[56] rddataout_1[55] rddataout_1[54] rddataout_1[53] rddataout_1[52]
+ rddataout_1[51] rddataout_1[50] rddataout_1[49] rddataout_1[48] rddataout_1[47]
+ rddataout_1[46] rddataout_1[45] rddataout_1[44] rddataout_1[43] rddataout_1[42]
+ rddataout_1[41] rddataout_1[40] rddataout_1[39] rddataout_1[38] rddataout_1[37]
+ rddataout_1[36] rddataout_1[35] rddataout_1[34] rddataout_1[33] rddataout_1[32]
+ rddataout_1[31] rddataout_1[30] rddataout_1[29] rddataout_1[28] rddataout_1[27]
+ rddataout_1[26] rddataout_1[25] rddataout_1[24] rddataout_1[23] rddataout_1[22]
+ rddataout_1[21] rddataout_1[20] rddataout_1[19] rddataout_1[18] rddataout_1[17]
+ rddataout_1[16] rddataout_1[15] rddataout_1[14] rddataout_1[13] rddataout_1[12]
+ rddataout_1[11] rddataout_1[10] rddataout_1[9] rddataout_1[8] rddataout_1[7] rddataout_1[6]
+ rddataout_1[5] rddataout_1[4] rddataout_1[3] rddataout_1[2] rddataout_1[1] rddataout_1[0]
+ sideen[0] turbomode turbomode# vcc vss wayselbnk[3] wayselbnk[2] wayselbnk[1]
+ wayselbnk[0] ip78d6hcf2sr4096x135m4i2k4w8r2lya_gio
Xsramsubbnk[0] activered#[1] activered#[0] bankgrant1h[0] clkbank fz_asynckick#
+ fz_asyncrd# fz_asyncwr# fz_finekick#[3] fz_finekick#[2] fz_finekick#[1] fz_finekick#[0]
+ fz_rassel#[2] fz_rassel#[1] fz_rassel#[0] fz_rdwlcut# fz_rdwlpw#[3] fz_rdwlpw#[2]
+ fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw#[1] fz_saepw#[0] fz_trbwassel#[2] fz_trbwassel#[1]
+ fz_trbwassel#[0] fz_trkwllvl#[2] fz_trkwllvl#[1] fz_trkwllvl#[0] fz_wassel#[2]
+ fz_wassel#[1] fz_wassel#[0] fz_wrwlcut# fz_wrwlpw#[1] fz_wrwlpw#[0] bankgrant1l[0]
+ bankgrant2h[0] ia_hi#[2] ia_hi#[1] ia_hi#[0] ia_mid#[2] ia_mid#[1] ia_mid#[0]
+ ia_wle#[1] ia_wle#[0] idin1l[134] idin1l[133] idin1l[132] idin1l[131] idin1l[130]
+ idin1l[129] idin1l[128] idin1l[127] idin1l[126] idin1l[125] idin1l[124] idin1l[123]
+ idin1l[122] idin1l[121] idin1l[120] idin1l[119] idin1l[118] idin1l[117] idin1l[116]
+ idin1l[115] idin1l[114] idin1l[113] idin1l[112] idin1l[111] idin1l[110] idin1l[109]
+ idin1l[108] idin1l[107] idin1l[106] idin1l[105] idin1l[104] idin1l[103] idin1l[102]
+ idin1l[101] idin1l[100] idin1l[99] idin1l[98] idin1l[97] idin1l[96] idin1l[95]
+ idin1l[94] idin1l[93] idin1l[92] idin1l[91] idin1l[90] idin1l[89] idin1l[88] idin1l[87]
+ idin1l[86] idin1l[85] idin1l[84] idin1l[83] idin1l[82] idin1l[81] idin1l[80] idin1l[79]
+ idin1l[78] idin1l[77] idin1l[76] idin1l[75] idin1l[74] idin1l[73] idin1l[72] idin1l[71]
+ idin1l[70] idin1l[69] idin1l[68] idin1l[67] idin1l[66] idin1l[65] idin1l[64] idin1l[63]
+ idin1l[62] idin1l[61] idin1l[60] idin1l[59] idin1l[58] idin1l[57] idin1l[56] idin1l[55]
+ idin1l[54] idin1l[53] idin1l[52] idin1l[51] idin1l[50] idin1l[49] idin1l[48] idin1l[47]
+ idin1l[46] idin1l[45] idin1l[44] idin1l[43] idin1l[42] idin1l[41] idin1l[40] idin1l[39]
+ idin1l[38] idin1l[37] idin1l[36] idin1l[35] idin1l[34] idin1l[33] idin1l[32] idin1l[31]
+ idin1l[30] idin1l[29] idin1l[28] idin1l[27] idin1l[26] idin1l[25] idin1l[24] idin1l[23]
+ idin1l[22] idin1l[21] idin1l[20] idin1l[19] idin1l[18] idin1l[17] idin1l[16] idin1l[15]
+ idin1l[14] idin1l[13] idin1l[12] idin1l[11] idin1l[10] idin1l[9] idin1l[8] idin1l[7]
+ idin1l[6] idin1l[5] idin1l[4] idin1l[3] idin1l[2] idin1l[1] idin1l[0] iwren1h
+ iwren1l2l iwren2h3h lyal0bl[134] lyal0bl[133] lyal0bl[132] lyal0bl[131] lyal0bl[130]
+ lyal0bl[129] lyal0bl[128] lyal0bl[127] lyal0bl[126] lyal0bl[125] lyal0bl[124]
+ lyal0bl[123] lyal0bl[122] lyal0bl[121] lyal0bl[120] lyal0bl[119] lyal0bl[118]
+ lyal0bl[117] lyal0bl[116] lyal0bl[115] lyal0bl[114] lyal0bl[113] lyal0bl[112]
+ lyal0bl[111] lyal0bl[110] lyal0bl[109] lyal0bl[108] lyal0bl[107] lyal0bl[106]
+ lyal0bl[105] lyal0bl[104] lyal0bl[103] lyal0bl[102] lyal0bl[101] lyal0bl[100]
+ lyal0bl[99] lyal0bl[98] lyal0bl[97] lyal0bl[96] lyal0bl[95] lyal0bl[94] lyal0bl[93]
+ lyal0bl[92] lyal0bl[91] lyal0bl[90] lyal0bl[89] lyal0bl[88] lyal0bl[87] lyal0bl[86]
+ lyal0bl[85] lyal0bl[84] lyal0bl[83] lyal0bl[82] lyal0bl[81] lyal0bl[80] lyal0bl[79]
+ lyal0bl[78] lyal0bl[77] lyal0bl[76] lyal0bl[75] lyal0bl[74] lyal0bl[73] lyal0bl[72]
+ lyal0bl[71] lyal0bl[70] lyal0bl[69] lyal0bl[68] lyal0bl[67] lyal0bl[66] lyal0bl[65]
+ lyal0bl[64] lyal0bl[63] lyal0bl[62] lyal0bl[61] lyal0bl[60] lyal0bl[59] lyal0bl[58]
+ lyal0bl[57] lyal0bl[56] lyal0bl[55] lyal0bl[54] lyal0bl[53] lyal0bl[52] lyal0bl[51]
+ lyal0bl[50] lyal0bl[49] lyal0bl[48] lyal0bl[47] lyal0bl[46] lyal0bl[45] lyal0bl[44]
+ lyal0bl[43] lyal0bl[42] lyal0bl[41] lyal0bl[40] lyal0bl[39] lyal0bl[38] lyal0bl[37]
+ lyal0bl[36] lyal0bl[35] lyal0bl[34] lyal0bl[33] lyal0bl[32] lyal0bl[31] lyal0bl[30]
+ lyal0bl[29] lyal0bl[28] lyal0bl[27] lyal0bl[26] lyal0bl[25] lyal0bl[24] lyal0bl[23]
+ lyal0bl[22] lyal0bl[21] lyal0bl[20] lyal0bl[19] lyal0bl[18] lyal0bl[17] lyal0bl[16]
+ lyal0bl[15] lyal0bl[14] lyal0bl[13] lyal0bl[12] lyal0bl[11] lyal0bl[10] lyal0bl[9]
+ lyal0bl[8] lyal0bl[7] lyal0bl[6] lyal0bl[5] lyal0bl[4] lyal0bl[3] lyal0bl[2] lyal0bl[1]
+ lyal0bl[0] lyal0blnn[134] lyal0blnn[133] lyal0blnn[132] lyal0blnn[131] lyal0blnn[130]
+ lyal0blnn[129] lyal0blnn[128] lyal0blnn[127] lyal0blnn[126] lyal0blnn[125] lyal0blnn[124]
+ lyal0blnn[123] lyal0blnn[122] lyal0blnn[121] lyal0blnn[120] lyal0blnn[119] lyal0blnn[118]
+ lyal0blnn[117] lyal0blnn[116] lyal0blnn[115] lyal0blnn[114] lyal0blnn[113] lyal0blnn[112]
+ lyal0blnn[111] lyal0blnn[110] lyal0blnn[109] lyal0blnn[108] lyal0blnn[107] lyal0blnn[106]
+ lyal0blnn[105] lyal0blnn[104] lyal0blnn[103] lyal0blnn[102] lyal0blnn[101] lyal0blnn[100]
+ lyal0blnn[99] lyal0blnn[98] lyal0blnn[97] lyal0blnn[96] lyal0blnn[95] lyal0blnn[94]
+ lyal0blnn[93] lyal0blnn[92] lyal0blnn[91] lyal0blnn[90] lyal0blnn[89] lyal0blnn[88]
+ lyal0blnn[87] lyal0blnn[86] lyal0blnn[85] lyal0blnn[84] lyal0blnn[83] lyal0blnn[82]
+ lyal0blnn[81] lyal0blnn[80] lyal0blnn[79] lyal0blnn[78] lyal0blnn[77] lyal0blnn[76]
+ lyal0blnn[75] lyal0blnn[74] lyal0blnn[73] lyal0blnn[72] lyal0blnn[71] lyal0blnn[70]
+ lyal0blnn[69] lyal0blnn[68] lyal0blnn[67] lyal0blnn[66] lyal0blnn[65] lyal0blnn[64]
+ lyal0blnn[63] lyal0blnn[62] lyal0blnn[61] lyal0blnn[60] lyal0blnn[59] lyal0blnn[58]
+ lyal0blnn[57] lyal0blnn[56] lyal0blnn[55] lyal0blnn[54] lyal0blnn[53] lyal0blnn[52]
+ lyal0blnn[51] lyal0blnn[50] lyal0blnn[49] lyal0blnn[48] lyal0blnn[47] lyal0blnn[46]
+ lyal0blnn[45] lyal0blnn[44] lyal0blnn[43] lyal0blnn[42] lyal0blnn[41] lyal0blnn[40]
+ lyal0blnn[39] lyal0blnn[38] lyal0blnn[37] lyal0blnn[36] lyal0blnn[35] lyal0blnn[34]
+ lyal0blnn[33] lyal0blnn[32] lyal0blnn[31] lyal0blnn[30] lyal0blnn[29] lyal0blnn[28]
+ lyal0blnn[27] lyal0blnn[26] lyal0blnn[25] lyal0blnn[24] lyal0blnn[23] lyal0blnn[22]
+ lyal0blnn[21] lyal0blnn[20] lyal0blnn[19] lyal0blnn[18] lyal0blnn[17] lyal0blnn[16]
+ lyal0blnn[15] lyal0blnn[14] lyal0blnn[13] lyal0blnn[12] lyal0blnn[11] lyal0blnn[10]
+ lyal0blnn[9] lyal0blnn[8] lyal0blnn[7] lyal0blnn[6] lyal0blnn[5] lyal0blnn[4]
+ lyal0blnn[3] lyal0blnn[2] lyal0blnn[1] lyal0blnn[0] lyanowl# lyaseltmr rddataout_0[134]
+ rddataout_0[133] rddataout_0[132] rddataout_0[131] rddataout_0[130] rddataout_0[129]
+ rddataout_0[128] rddataout_0[127] rddataout_0[126] rddataout_0[125] rddataout_0[124]
+ rddataout_0[123] rddataout_0[122] rddataout_0[121] rddataout_0[120] rddataout_0[119]
+ rddataout_0[118] rddataout_0[117] rddataout_0[116] rddataout_0[115] rddataout_0[114]
+ rddataout_0[113] rddataout_0[112] rddataout_0[111] rddataout_0[110] rddataout_0[109]
+ rddataout_0[108] rddataout_0[107] rddataout_0[106] rddataout_0[105] rddataout_0[104]
+ rddataout_0[103] rddataout_0[102] rddataout_0[101] rddataout_0[100] rddataout_0[99]
+ rddataout_0[98] rddataout_0[97] rddataout_0[96] rddataout_0[95] rddataout_0[94]
+ rddataout_0[93] rddataout_0[92] rddataout_0[91] rddataout_0[90] rddataout_0[89]
+ rddataout_0[88] rddataout_0[87] rddataout_0[86] rddataout_0[85] rddataout_0[84]
+ rddataout_0[83] rddataout_0[82] rddataout_0[81] rddataout_0[80] rddataout_0[79]
+ rddataout_0[78] rddataout_0[77] rddataout_0[76] rddataout_0[75] rddataout_0[74]
+ rddataout_0[73] rddataout_0[72] rddataout_0[71] rddataout_0[70] rddataout_0[69]
+ rddataout_0[68] rddataout_0[67] rddataout_0[66] rddataout_0[65] rddataout_0[64]
+ rddataout_0[63] rddataout_0[62] rddataout_0[61] rddataout_0[60] rddataout_0[59]
+ rddataout_0[58] rddataout_0[57] rddataout_0[56] rddataout_0[55] rddataout_0[54]
+ rddataout_0[53] rddataout_0[52] rddataout_0[51] rddataout_0[50] rddataout_0[49]
+ rddataout_0[48] rddataout_0[47] rddataout_0[46] rddataout_0[45] rddataout_0[44]
+ rddataout_0[43] rddataout_0[42] rddataout_0[41] rddataout_0[40] rddataout_0[39]
+ rddataout_0[38] rddataout_0[37] rddataout_0[36] rddataout_0[35] rddataout_0[34]
+ rddataout_0[33] rddataout_0[32] rddataout_0[31] rddataout_0[30] rddataout_0[29]
+ rddataout_0[28] rddataout_0[27] rddataout_0[26] rddataout_0[25] rddataout_0[24]
+ rddataout_0[23] rddataout_0[22] rddataout_0[21] rddataout_0[20] rddataout_0[19]
+ rddataout_0[18] rddataout_0[17] rddataout_0[16] rddataout_0[15] rddataout_0[14]
+ rddataout_0[13] rddataout_0[12] rddataout_0[11] rddataout_0[10] rddataout_0[9]
+ rddataout_0[8] rddataout_0[7] rddataout_0[6] rddataout_0[5] rddataout_0[4] rddataout_0[3]
+ rddataout_0[2] rddataout_0[1] rddataout_0[0] sideen[0] turbomode# vcc vss wayselbnk[3]
+ wayselbnk[2] wayselbnk[1] wayselbnk[0] ip78d6hcf2sr4096x135m4i2k4w8r2lya_subbnk
Xsramsubbnk[1] activered#[1] activered#[0] bankgrant1h[1] clkbank fz_asynckick#
+ fz_asyncrd# fz_asyncwr# fz_finekick#[3] fz_finekick#[2] fz_finekick#[1] fz_finekick#[0]
+ fz_rassel#[2] fz_rassel#[1] fz_rassel#[0] fz_rdwlcut# fz_rdwlpw#[3] fz_rdwlpw#[2]
+ fz_rdwlpw#[1] fz_rdwlpw#[0] fz_saepw#[1] fz_saepw#[0] fz_trbwassel#[2] fz_trbwassel#[1]
+ fz_trbwassel#[0] fz_trkwllvl#[2] fz_trkwllvl#[1] fz_trkwllvl#[0] fz_wassel#[2]
+ fz_wassel#[1] fz_wassel#[0] fz_wrwlcut# fz_wrwlpw#[1] fz_wrwlpw#[0] bankgrant1l[1]
+ bankgrant2h[1] ia_hi#[2] ia_hi#[1] ia_hi#[0] ia_mid#[2] ia_mid#[1] ia_mid#[0]
+ ia_wle#[1] ia_wle#[0] idin1l[134] idin1l[133] idin1l[132] idin1l[131] idin1l[130]
+ idin1l[129] idin1l[128] idin1l[127] idin1l[126] idin1l[125] idin1l[124] idin1l[123]
+ idin1l[122] idin1l[121] idin1l[120] idin1l[119] idin1l[118] idin1l[117] idin1l[116]
+ idin1l[115] idin1l[114] idin1l[113] idin1l[112] idin1l[111] idin1l[110] idin1l[109]
+ idin1l[108] idin1l[107] idin1l[106] idin1l[105] idin1l[104] idin1l[103] idin1l[102]
+ idin1l[101] idin1l[100] idin1l[99] idin1l[98] idin1l[97] idin1l[96] idin1l[95]
+ idin1l[94] idin1l[93] idin1l[92] idin1l[91] idin1l[90] idin1l[89] idin1l[88] idin1l[87]
+ idin1l[86] idin1l[85] idin1l[84] idin1l[83] idin1l[82] idin1l[81] idin1l[80] idin1l[79]
+ idin1l[78] idin1l[77] idin1l[76] idin1l[75] idin1l[74] idin1l[73] idin1l[72] idin1l[71]
+ idin1l[70] idin1l[69] idin1l[68] idin1l[67] idin1l[66] idin1l[65] idin1l[64] idin1l[63]
+ idin1l[62] idin1l[61] idin1l[60] idin1l[59] idin1l[58] idin1l[57] idin1l[56] idin1l[55]
+ idin1l[54] idin1l[53] idin1l[52] idin1l[51] idin1l[50] idin1l[49] idin1l[48] idin1l[47]
+ idin1l[46] idin1l[45] idin1l[44] idin1l[43] idin1l[42] idin1l[41] idin1l[40] idin1l[39]
+ idin1l[38] idin1l[37] idin1l[36] idin1l[35] idin1l[34] idin1l[33] idin1l[32] idin1l[31]
+ idin1l[30] idin1l[29] idin1l[28] idin1l[27] idin1l[26] idin1l[25] idin1l[24] idin1l[23]
+ idin1l[22] idin1l[21] idin1l[20] idin1l[19] idin1l[18] idin1l[17] idin1l[16] idin1l[15]
+ idin1l[14] idin1l[13] idin1l[12] idin1l[11] idin1l[10] idin1l[9] idin1l[8] idin1l[7]
+ idin1l[6] idin1l[5] idin1l[4] idin1l[3] idin1l[2] idin1l[1] idin1l[0] iwren1h
+ iwren1l2l iwren2h3h lyal0bl[134] lyal0bl[133] lyal0bl[132] lyal0bl[131] lyal0bl[130]
+ lyal0bl[129] lyal0bl[128] lyal0bl[127] lyal0bl[126] lyal0bl[125] lyal0bl[124]
+ lyal0bl[123] lyal0bl[122] lyal0bl[121] lyal0bl[120] lyal0bl[119] lyal0bl[118]
+ lyal0bl[117] lyal0bl[116] lyal0bl[115] lyal0bl[114] lyal0bl[113] lyal0bl[112]
+ lyal0bl[111] lyal0bl[110] lyal0bl[109] lyal0bl[108] lyal0bl[107] lyal0bl[106]
+ lyal0bl[105] lyal0bl[104] lyal0bl[103] lyal0bl[102] lyal0bl[101] lyal0bl[100]
+ lyal0bl[99] lyal0bl[98] lyal0bl[97] lyal0bl[96] lyal0bl[95] lyal0bl[94] lyal0bl[93]
+ lyal0bl[92] lyal0bl[91] lyal0bl[90] lyal0bl[89] lyal0bl[88] lyal0bl[87] lyal0bl[86]
+ lyal0bl[85] lyal0bl[84] lyal0bl[83] lyal0bl[82] lyal0bl[81] lyal0bl[80] lyal0bl[79]
+ lyal0bl[78] lyal0bl[77] lyal0bl[76] lyal0bl[75] lyal0bl[74] lyal0bl[73] lyal0bl[72]
+ lyal0bl[71] lyal0bl[70] lyal0bl[69] lyal0bl[68] lyal0bl[67] lyal0bl[66] lyal0bl[65]
+ lyal0bl[64] lyal0bl[63] lyal0bl[62] lyal0bl[61] lyal0bl[60] lyal0bl[59] lyal0bl[58]
+ lyal0bl[57] lyal0bl[56] lyal0bl[55] lyal0bl[54] lyal0bl[53] lyal0bl[52] lyal0bl[51]
+ lyal0bl[50] lyal0bl[49] lyal0bl[48] lyal0bl[47] lyal0bl[46] lyal0bl[45] lyal0bl[44]
+ lyal0bl[43] lyal0bl[42] lyal0bl[41] lyal0bl[40] lyal0bl[39] lyal0bl[38] lyal0bl[37]
+ lyal0bl[36] lyal0bl[35] lyal0bl[34] lyal0bl[33] lyal0bl[32] lyal0bl[31] lyal0bl[30]
+ lyal0bl[29] lyal0bl[28] lyal0bl[27] lyal0bl[26] lyal0bl[25] lyal0bl[24] lyal0bl[23]
+ lyal0bl[22] lyal0bl[21] lyal0bl[20] lyal0bl[19] lyal0bl[18] lyal0bl[17] lyal0bl[16]
+ lyal0bl[15] lyal0bl[14] lyal0bl[13] lyal0bl[12] lyal0bl[11] lyal0bl[10] lyal0bl[9]
+ lyal0bl[8] lyal0bl[7] lyal0bl[6] lyal0bl[5] lyal0bl[4] lyal0bl[3] lyal0bl[2] lyal0bl[1]
+ lyal0bl[0] lyal0blnn[134] lyal0blnn[133] lyal0blnn[132] lyal0blnn[131] lyal0blnn[130]
+ lyal0blnn[129] lyal0blnn[128] lyal0blnn[127] lyal0blnn[126] lyal0blnn[125] lyal0blnn[124]
+ lyal0blnn[123] lyal0blnn[122] lyal0blnn[121] lyal0blnn[120] lyal0blnn[119] lyal0blnn[118]
+ lyal0blnn[117] lyal0blnn[116] lyal0blnn[115] lyal0blnn[114] lyal0blnn[113] lyal0blnn[112]
+ lyal0blnn[111] lyal0blnn[110] lyal0blnn[109] lyal0blnn[108] lyal0blnn[107] lyal0blnn[106]
+ lyal0blnn[105] lyal0blnn[104] lyal0blnn[103] lyal0blnn[102] lyal0blnn[101] lyal0blnn[100]
+ lyal0blnn[99] lyal0blnn[98] lyal0blnn[97] lyal0blnn[96] lyal0blnn[95] lyal0blnn[94]
+ lyal0blnn[93] lyal0blnn[92] lyal0blnn[91] lyal0blnn[90] lyal0blnn[89] lyal0blnn[88]
+ lyal0blnn[87] lyal0blnn[86] lyal0blnn[85] lyal0blnn[84] lyal0blnn[83] lyal0blnn[82]
+ lyal0blnn[81] lyal0blnn[80] lyal0blnn[79] lyal0blnn[78] lyal0blnn[77] lyal0blnn[76]
+ lyal0blnn[75] lyal0blnn[74] lyal0blnn[73] lyal0blnn[72] lyal0blnn[71] lyal0blnn[70]
+ lyal0blnn[69] lyal0blnn[68] lyal0blnn[67] lyal0blnn[66] lyal0blnn[65] lyal0blnn[64]
+ lyal0blnn[63] lyal0blnn[62] lyal0blnn[61] lyal0blnn[60] lyal0blnn[59] lyal0blnn[58]
+ lyal0blnn[57] lyal0blnn[56] lyal0blnn[55] lyal0blnn[54] lyal0blnn[53] lyal0blnn[52]
+ lyal0blnn[51] lyal0blnn[50] lyal0blnn[49] lyal0blnn[48] lyal0blnn[47] lyal0blnn[46]
+ lyal0blnn[45] lyal0blnn[44] lyal0blnn[43] lyal0blnn[42] lyal0blnn[41] lyal0blnn[40]
+ lyal0blnn[39] lyal0blnn[38] lyal0blnn[37] lyal0blnn[36] lyal0blnn[35] lyal0blnn[34]
+ lyal0blnn[33] lyal0blnn[32] lyal0blnn[31] lyal0blnn[30] lyal0blnn[29] lyal0blnn[28]
+ lyal0blnn[27] lyal0blnn[26] lyal0blnn[25] lyal0blnn[24] lyal0blnn[23] lyal0blnn[22]
+ lyal0blnn[21] lyal0blnn[20] lyal0blnn[19] lyal0blnn[18] lyal0blnn[17] lyal0blnn[16]
+ lyal0blnn[15] lyal0blnn[14] lyal0blnn[13] lyal0blnn[12] lyal0blnn[11] lyal0blnn[10]
+ lyal0blnn[9] lyal0blnn[8] lyal0blnn[7] lyal0blnn[6] lyal0blnn[5] lyal0blnn[4]
+ lyal0blnn[3] lyal0blnn[2] lyal0blnn[1] lyal0blnn[0] lyanowl# lyaseltmr rddataout_1[134]
+ rddataout_1[133] rddataout_1[132] rddataout_1[131] rddataout_1[130] rddataout_1[129]
+ rddataout_1[128] rddataout_1[127] rddataout_1[126] rddataout_1[125] rddataout_1[124]
+ rddataout_1[123] rddataout_1[122] rddataout_1[121] rddataout_1[120] rddataout_1[119]
+ rddataout_1[118] rddataout_1[117] rddataout_1[116] rddataout_1[115] rddataout_1[114]
+ rddataout_1[113] rddataout_1[112] rddataout_1[111] rddataout_1[110] rddataout_1[109]
+ rddataout_1[108] rddataout_1[107] rddataout_1[106] rddataout_1[105] rddataout_1[104]
+ rddataout_1[103] rddataout_1[102] rddataout_1[101] rddataout_1[100] rddataout_1[99]
+ rddataout_1[98] rddataout_1[97] rddataout_1[96] rddataout_1[95] rddataout_1[94]
+ rddataout_1[93] rddataout_1[92] rddataout_1[91] rddataout_1[90] rddataout_1[89]
+ rddataout_1[88] rddataout_1[87] rddataout_1[86] rddataout_1[85] rddataout_1[84]
+ rddataout_1[83] rddataout_1[82] rddataout_1[81] rddataout_1[80] rddataout_1[79]
+ rddataout_1[78] rddataout_1[77] rddataout_1[76] rddataout_1[75] rddataout_1[74]
+ rddataout_1[73] rddataout_1[72] rddataout_1[71] rddataout_1[70] rddataout_1[69]
+ rddataout_1[68] rddataout_1[67] rddataout_1[66] rddataout_1[65] rddataout_1[64]
+ rddataout_1[63] rddataout_1[62] rddataout_1[61] rddataout_1[60] rddataout_1[59]
+ rddataout_1[58] rddataout_1[57] rddataout_1[56] rddataout_1[55] rddataout_1[54]
+ rddataout_1[53] rddataout_1[52] rddataout_1[51] rddataout_1[50] rddataout_1[49]
+ rddataout_1[48] rddataout_1[47] rddataout_1[46] rddataout_1[45] rddataout_1[44]
+ rddataout_1[43] rddataout_1[42] rddataout_1[41] rddataout_1[40] rddataout_1[39]
+ rddataout_1[38] rddataout_1[37] rddataout_1[36] rddataout_1[35] rddataout_1[34]
+ rddataout_1[33] rddataout_1[32] rddataout_1[31] rddataout_1[30] rddataout_1[29]
+ rddataout_1[28] rddataout_1[27] rddataout_1[26] rddataout_1[25] rddataout_1[24]
+ rddataout_1[23] rddataout_1[22] rddataout_1[21] rddataout_1[20] rddataout_1[19]
+ rddataout_1[18] rddataout_1[17] rddataout_1[16] rddataout_1[15] rddataout_1[14]
+ rddataout_1[13] rddataout_1[12] rddataout_1[11] rddataout_1[10] rddataout_1[9]
+ rddataout_1[8] rddataout_1[7] rddataout_1[6] rddataout_1[5] rddataout_1[4] rddataout_1[3]
+ rddataout_1[2] rddataout_1[1] rddataout_1[0] sideen[0] turbomode# vcc vss wayselbnk[3]
+ wayselbnk[2] wayselbnk[1] wayselbnk[0] ip78d6hcf2sr4096x135m4i2k4w8r2lya_subbnk
.ENDS

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mzdcf33ub1n32x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mzdcf33ub1n16x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mzdcf33ub1n08x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mzdcf33ub1n04x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mydp122uc1n00x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mydp122ub1n00x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0morn002ac1n09x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0morn002ac1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor042ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor003ac1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor003ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor003ab1n12x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor003ab1n10x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor003ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor002ac1n16x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor002ac1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor002ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor002ac1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor002ab1n12x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor002ab1n10x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor002ab1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnor002ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand04ac1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand03ac1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand03ac1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand03ab1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand03ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand02ac1n16x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand02ac1n10x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand02ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand02ac1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand02ab1n12x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand02ab1n10x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand02ab1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand02ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mnand02ab1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mlun090ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mlun090ac1d06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mlun090ab1d06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mlsnan3ab1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mlsn080ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mlsn080ac1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mlsn000ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ac1n36x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ac1n24x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ac1n15x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ac1n12x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ac1n09x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ac1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ac1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ab1n36x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ab1n30x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ab1n15x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ab1n12x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ab1n09x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ab1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ab1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0minv000ab1d42x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mfhn000ac1d02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mclbno3ab1n04x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mclbno2ab1n12x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mclbno2ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mclbna3ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mclbna2ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mcinv00ab1n36x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mcinv00ab1n24x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mcinv00ab1n12x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mcinv00ab1n04x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mcbf000ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ac1n18x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ac1n12x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ac1n09x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ac1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ac1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ac1d42x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ab1n36x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ab1n30x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ab1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfn000ab1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm807ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm807ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm605ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm604ac1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm604ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm402ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm402ac1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm402ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm202ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm201ac1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm201ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm201ac1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm201ab1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm201ab1n04x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm201ab1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mbfm201ab1n02x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0maoi022ac1n06x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0maoi012ab1n09x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mand002ac1n03x5.sp
*  End of subcircuit definition.

*/nfs/site/proj/mpg/proc/projects/db_root/i86memip/i0m_cltr_i86memip/std/pncstd_786_i0m_pdk090_r1v0p0_fv/i0m_cltr/sp/i0mand002ac1n02x5.sp
*  End of subcircuit definition.

*/p/hdk/cad/pdk/pdk786_r0.9iHP1_24ww17.5/libraries/tic/cdl/m14_2x_1xa_1xb_6ya_2yb_2yc__bm5_1ye_1yf_2ga_mim3x_1gb__padh/intel78tic.cdl
*** End of intel78tic.cdl
